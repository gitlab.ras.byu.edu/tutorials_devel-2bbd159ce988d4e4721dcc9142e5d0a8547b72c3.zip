simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 7 of 116)

== system roach2_tut_corr/snap_adc0/basic_ctrl ==
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  trig : Inport  Port=4
  ctrl : Inport  Port=5
  stopi : Inport  Port=6
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Register1 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register6 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  dram_munge : Subsystem
  edge_detect : casper_library_misc/edge_detect  edge=Rising  polarity=Active High  x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4]  y_in="[-1 -1  1  1  1  1  1  1  1  1]"  x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1]  y_out="[-1 -1  1  1 -1 -1 -1 -1 -1 -1]"
      link override Delay: sg_icon_stat=45,16,1,1,white,blue,0,07b98262,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override Inverter: sg_icon_stat=45,16,1,1,white,blue,0,267846e5,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override edge_op: sg_icon_stat=45,44,2,1,white,blue,0,affe8783,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 44 44 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 44 44 0 ]); patch([8.65 17.32 23.32 29.32 35.32 23.32 14.65 8.65 ],[28.66 28.66 34.66 28.66 34.66 34.66 34.66 28.66 ],[1 1 1 ]); patch([14.65 23.32 17.32 8.65 14.65 ],[22.66 22.66 28.66 28.66 22.66 ],[0.931 0.946 0.973 ]); patch([8.65 17.32 23.32 14.65 8.65 ],[16.66 16.66 22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
  enable : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  trig_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  valid_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=2  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  dout : Outport  Port=2
  we_o : Outport  Port=3
  go : Outport  Port=4
  stop : Outport  Port=5
  init : Outport  Port=6
  wires:
  Delay1/1 -> edge_detect/1
  Delay3/1 -> Mux1/1
  Delay2/1 -> Mux2/1
  dram_munge/1(vout) -> vout/1
  vin/1 -> dram_munge/1(vin)
  dram_munge/3(we_o) -> we_o/1
  dram_munge/2(dout) -> dout/1
  din/1 -> dram_munge/2(din)
  Inverter/1 -> Logical/2
  Mux2/1 -> Logical/1, Register6/1
  Register6/1 -> go/1
  trig/1 -> Mux2/2
  Mux1/1 -> dram_munge/3(we)
  we/1 -> Mux1/2
  ctrl/1 -> enable/1, valid_src/1, trig_src/1
  edge_detect/1 -> Inverter/1, Register1/3, dram_munge/4(init), Register6/2, init/1
  enable/1 -> Delay1/1
  Constant1/1 -> Mux2/3
  Constant2/1 -> Mux1/3
  trig_src/1 -> Delay2/1
  valid_src/1 -> Delay3/1
  Constant/1 -> Register1/1
  Register1/1 -> Register6/3
  Logical/1 -> Register1/2
  stopi/1 -> stop/1

== system roach2_tut_corr/snap_adc0/bram ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_snap_adc0_bram_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc0_bram_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc0_bram_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_snap_adc0_bram_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_snap_adc0_bram_addr/1
  convert_din1/1 -> roach2_tut_corr_snap_adc0_bram_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_snap_adc0_bram_we/1 -> mem/3(In3)
  roach2_tut_corr_snap_adc0_bram_data_in/1 -> mem/2(In2)
  roach2_tut_corr_snap_adc0_bram_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_snap_adc0_bram_we/1
  roach2_tut_corr_snap_adc0_bram_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_snap_adc0_bram_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/snap_adc0/ctrl ==
  sim_1 : Inport
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc0_ctrl_user_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  slice_reg : xbsIndex_r4/Slice  nbits=32  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  in_reg : Outport
  wires:
  roach2_tut_corr_snap_adc0_ctrl_user_data_out/1 -> io_delay/1
  sim_1/1 -> roach2_tut_corr_snap_adc0_ctrl_user_data_out/1
  io_delay/1 -> slice_reg/1
  slice_reg/1 -> reint1/1
  reint1/1 -> in_reg/1

== system roach2_tut_corr/snap_adc0/status ==
  out_reg : Inport
  assert_reg : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  cast_gw : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc0_status_user_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_out : Outport
  wires:
  io_delay/1 -> cast_gw/1
  cast_gw/1 -> roach2_tut_corr_snap_adc0_status_user_data_in/1
  roach2_tut_corr_snap_adc0_status_user_data_in/1 -> sim_out/1
  out_reg/1 -> assert_reg/1
  assert_reg/1 -> reint1/1
  reint1/1 -> io_delay/1

== system roach2_tut_corr/snap_adc1/add_gen ==
  note: To storage
  note: prevent one extra write to address 0
  note: Do one capture by default
  note: Count of bytes in BRAM as well as done signal
  note: A total count of bytes written to BRAM since trig
  note: Force MSbit of count to be '1' by negating busy as counter bit may be '0' or '1'
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  go : Inport  Port=4
  cont : Inport  Port=5
  init : Inport  Port=6
  Concat : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  Convert : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32-nsamples-log2(increment)-1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  Delay{,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay7 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=1  dbl_ovrd=off  block_type=inv
  Inverter1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical1 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical2 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical4 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical6 : xbsIndex_r4/Logical  logical_function=AND  inputs=3  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Register3 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register4 : xbsIndex_r4/Register  init=0  rst=off  en=on  dbl_ovrd=off  block_type=register
  Register5 : xbsIndex_r4/Register  init=1  rst=on  en=on  dbl_ovrd=off  block_type=register
  Shift : xbsIndex_r4/Shift  shift_dir=Left  shift_bits=32-nsamples-log2(increment)-1-1  en=off  latency=1  precision=Full  arith_type="Signed  (2's comp)"  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=shift
  add_gen : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1  operation=Up  start_count=0  cnt_by_val=increment  arith_type=Unsigned  n_bits=counter_size  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=DSP48  use_rpm=on  block_type=counter
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect
  slice1 : xbsIndex_r4/Slice  nbits=nsamples+log2(increment)  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=nsamples-burst_size  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=log2(increment)+burst_size  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=nsamples + log2(increment)  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  add : Outport  Port=2
  dout : Outport  Port=3
  we_o : Outport  Port=4
  status : Outport  Port=5
  en_cnt : Outport  Port=6
  wires:
  Shift/1 -> Concat/1
  Delay/1 -> Register5/2
  Inverter1/1 -> Logical4/2
  cont/1 -> Delay3/1
  edge_detect/1(out) -> Inverter1/1, Register5/3
  Register4/1 -> vout/1
  Logical2/1 -> Register4/2
  Register3/1 -> Logical2/2
  vin/1 -> Delay5/1
  add_gen/1 -> slice2/1, slice1/1, Delay2/1, slice3/1
  Register5/1 -> Convert/1, Inverter/1, Logical6/1
  slice3/1 -> edge_detect/1(in)
  init/1 -> Delay4/1
  Logical6/1 -> we_o/1, Logical2/1, Register3/2, add_gen/2
  Concat/1 -> status/1
  Convert/1 -> Shift/1
  slice2/1 -> add/1
  Delay2/1 -> en_cnt/1
  din/1 -> Delay6/1
  Delay1/1 -> Concat/3
  slice1/1 -> Delay1/1
  Inverter/1 -> Concat/2
  Logical4/1 -> Logical6/2
  we/1 -> Logical1/1
  go/1 -> Logical1/2
  Logical1/1 -> Logical6/3
  Delay7/1 -> Register4/1
  Delay3/1 -> Logical4/1, Register5/1
  Delay4/1 -> Register3/3, Register3/1, add_gen/1, Delay/1
  Delay5/1 -> Delay7/1
  Delay6/1 -> dout/1

== system roach2_tut_corr/snap_adc1/basic_ctrl ==
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  trig : Inport  Port=4
  ctrl : Inport  Port=5
  stopi : Inport  Port=6
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Register1 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register6 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  dram_munge : Subsystem
  edge_detect : casper_library_misc/edge_detect  edge=Rising  polarity=Active High  x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4]  y_in="[-1 -1  1  1  1  1  1  1  1  1]"  x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1]  y_out="[-1 -1  1  1 -1 -1 -1 -1 -1 -1]"
      link override Delay: sg_icon_stat=45,16,1,1,white,blue,0,07b98262,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override Inverter: sg_icon_stat=45,16,1,1,white,blue,0,267846e5,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override edge_op: sg_icon_stat=45,44,2,1,white,blue,0,affe8783,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 44 44 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 44 44 0 ]); patch([8.65 17.32 23.32 29.32 35.32 23.32 14.65 8.65 ],[28.66 28.66 34.66 28.66 34.66 34.66 34.66 28.66 ],[1 1 1 ]); patch([14.65 23.32 17.32 8.65 14.65 ],[22.66 22.66 28.66 28.66 22.66 ],[0.931 0.946 0.973 ]); patch([8.65 17.32 23.32 14.65 8.65 ],[16.66 16.66 22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
  enable : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  trig_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  valid_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=2  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  dout : Outport  Port=2
  we_o : Outport  Port=3
  go : Outport  Port=4
  stop : Outport  Port=5
  init : Outport  Port=6
  wires:
  Delay1/1 -> edge_detect/1
  Delay3/1 -> Mux1/1
  Delay2/1 -> Mux2/1
  dram_munge/1(vout) -> vout/1
  vin/1 -> dram_munge/1(vin)
  dram_munge/3(we_o) -> we_o/1
  dram_munge/2(dout) -> dout/1
  din/1 -> dram_munge/2(din)
  Inverter/1 -> Logical/2
  Mux2/1 -> Logical/1, Register6/1
  Register6/1 -> go/1
  trig/1 -> Mux2/2
  Mux1/1 -> dram_munge/3(we)
  we/1 -> Mux1/2
  ctrl/1 -> enable/1, valid_src/1, trig_src/1
  edge_detect/1 -> Inverter/1, Register1/3, dram_munge/4(init), Register6/2, init/1
  enable/1 -> Delay1/1
  Constant1/1 -> Mux2/3
  Constant2/1 -> Mux1/3
  trig_src/1 -> Delay2/1
  valid_src/1 -> Delay3/1
  Constant/1 -> Register1/1
  Register1/1 -> Register6/3
  Logical/1 -> Register1/2
  stopi/1 -> stop/1

== system roach2_tut_corr/snap_adc1/bram ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_snap_adc1_bram_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc1_bram_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc1_bram_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_snap_adc1_bram_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_snap_adc1_bram_addr/1
  convert_din1/1 -> roach2_tut_corr_snap_adc1_bram_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_snap_adc1_bram_we/1 -> mem/3(In3)
  roach2_tut_corr_snap_adc1_bram_data_in/1 -> mem/2(In2)
  roach2_tut_corr_snap_adc1_bram_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_snap_adc1_bram_we/1
  roach2_tut_corr_snap_adc1_bram_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_snap_adc1_bram_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/snap_adc1/ctrl ==
  sim_1 : Inport
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc1_ctrl_user_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  slice_reg : xbsIndex_r4/Slice  nbits=32  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  in_reg : Outport
  wires:
  roach2_tut_corr_snap_adc1_ctrl_user_data_out/1 -> io_delay/1
  sim_1/1 -> roach2_tut_corr_snap_adc1_ctrl_user_data_out/1
  io_delay/1 -> slice_reg/1
  slice_reg/1 -> reint1/1
  reint1/1 -> in_reg/1

== system roach2_tut_corr/snap_adc1/status ==
  out_reg : Inport
  assert_reg : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  cast_gw : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc1_status_user_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_out : Outport
  wires:
  io_delay/1 -> cast_gw/1
  cast_gw/1 -> roach2_tut_corr_snap_adc1_status_user_data_in/1
  roach2_tut_corr_snap_adc1_status_user_data_in/1 -> sim_out/1
  out_reg/1 -> assert_reg/1
  assert_reg/1 -> reint1/1
  reint1/1 -> io_delay/1

== system roach2_tut_corr/snap_adc2/add_gen ==
  note: To storage
  note: prevent one extra write to address 0
  note: Do one capture by default
  note: Count of bytes in BRAM as well as done signal
  note: A total count of bytes written to BRAM since trig
  note: Force MSbit of count to be '1' by negating busy as counter bit may be '0' or '1'
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  go : Inport  Port=4
  cont : Inport  Port=5
  init : Inport  Port=6
  Concat : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  Convert : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32-nsamples-log2(increment)-1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  Delay{,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay7 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=1  dbl_ovrd=off  block_type=inv
  Inverter1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical1 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical2 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical4 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical6 : xbsIndex_r4/Logical  logical_function=AND  inputs=3  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Register3 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register4 : xbsIndex_r4/Register  init=0  rst=off  en=on  dbl_ovrd=off  block_type=register
  Register5 : xbsIndex_r4/Register  init=1  rst=on  en=on  dbl_ovrd=off  block_type=register
  Shift : xbsIndex_r4/Shift  shift_dir=Left  shift_bits=32-nsamples-log2(increment)-1-1  en=off  latency=1  precision=Full  arith_type="Signed  (2's comp)"  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=shift
  add_gen : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1  operation=Up  start_count=0  cnt_by_val=increment  arith_type=Unsigned  n_bits=counter_size  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=DSP48  use_rpm=on  block_type=counter
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect
  slice1 : xbsIndex_r4/Slice  nbits=nsamples+log2(increment)  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=nsamples-burst_size  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=log2(increment)+burst_size  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=nsamples + log2(increment)  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  add : Outport  Port=2
  dout : Outport  Port=3
  we_o : Outport  Port=4
  status : Outport  Port=5
  en_cnt : Outport  Port=6
  wires:
  Shift/1 -> Concat/1
  Delay/1 -> Register5/2
  Inverter1/1 -> Logical4/2
  cont/1 -> Delay3/1
  edge_detect/1(out) -> Inverter1/1, Register5/3
  Register4/1 -> vout/1
  Logical2/1 -> Register4/2
  Register3/1 -> Logical2/2
  vin/1 -> Delay5/1
  add_gen/1 -> slice2/1, slice1/1, Delay2/1, slice3/1
  Register5/1 -> Convert/1, Inverter/1, Logical6/1
  slice3/1 -> edge_detect/1(in)
  init/1 -> Delay4/1
  Logical6/1 -> we_o/1, Logical2/1, Register3/2, add_gen/2
  Concat/1 -> status/1
  Convert/1 -> Shift/1
  slice2/1 -> add/1
  Delay2/1 -> en_cnt/1
  din/1 -> Delay6/1
  Delay1/1 -> Concat/3
  slice1/1 -> Delay1/1
  Inverter/1 -> Concat/2
  Logical4/1 -> Logical6/2
  we/1 -> Logical1/1
  go/1 -> Logical1/2
  Logical1/1 -> Logical6/3
  Delay7/1 -> Register4/1
  Delay3/1 -> Logical4/1, Register5/1
  Delay4/1 -> Register3/3, Register3/1, add_gen/1, Delay/1
  Delay5/1 -> Delay7/1
  Delay6/1 -> dout/1

== system roach2_tut_corr/snap_adc2/basic_ctrl ==
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  trig : Inport  Port=4
  ctrl : Inport  Port=5
  stopi : Inport  Port=6
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Register1 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register6 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  dram_munge : Subsystem
  edge_detect : casper_library_misc/edge_detect  edge=Rising  polarity=Active High  x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4]  y_in="[-1 -1  1  1  1  1  1  1  1  1]"  x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1]  y_out="[-1 -1  1  1 -1 -1 -1 -1 -1 -1]"
      link override Delay: sg_icon_stat=45,16,1,1,white,blue,0,07b98262,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override Inverter: sg_icon_stat=45,16,1,1,white,blue,0,267846e5,right,  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 1 1 0 ],[0 0 1 1 ],[0.77 0.82 0.91]); patch([0.422222 0.355556 0.444444 0.355556 0.422222 0.511111 0.533333 0.555556 0.666667 0.577778 0.511111 0.466667 0.555556 0.466667 0.511111 0.577778 0.666667 0.555556 0.533333 0.511111 0.422222 ],[0.125 0.3125 0.5625 0.8125 1 1 0.9375 1 1 0.75 0.9375 0.8125 0.5625 0.3125 0.1875 0.375 0.125 0.125 0.1875 0.1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
      link override edge_op: sg_icon_stat=45,44,2,1,white,blue,0,affe8783,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 44 44 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 44 44 0 ]); patch([8.65 17.32 23.32 29.32 35.32 23.32 14.65 8.65 ],[28.66 28.66 34.66 28.66 34.66 34.66 34.66 28.66 ],[1 1 1 ]); patch([14.65 23.32 17.32 8.65 14.65 ],[22.66 22.66 28.66 28.66 22.66 ],[0.931 0.946 0.973 ]); patch([8.65 17.32 23.32 14.65 8.65 ],[16.66 16.66 22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
  enable : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  trig_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  valid_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=2  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  dout : Outport  Port=2
  we_o : Outport  Port=3
  go : Outport  Port=4
  stop : Outport  Port=5
  init : Outport  Port=6
  wires:
  Delay1/1 -> edge_detect/1
  Delay3/1 -> Mux1/1
  Delay2/1 -> Mux2/1
  dram_munge/1(vout) -> vout/1
  vin/1 -> dram_munge/1(vin)
  dram_munge/3(we_o) -> we_o/1
  dram_munge/2(dout) -> dout/1
  din/1 -> dram_munge/2(din)
  Inverter/1 -> Logical/2
  Mux2/1 -> Logical/1, Register6/1
  Register6/1 -> go/1
  trig/1 -> Mux2/2
  Mux1/1 -> dram_munge/3(we)
  we/1 -> Mux1/2
  ctrl/1 -> enable/1, valid_src/1, trig_src/1
  edge_detect/1 -> Inverter/1, Register1/3, dram_munge/4(init), Register6/2, init/1
  enable/1 -> Delay1/1
  Constant1/1 -> Mux2/3
  Constant2/1 -> Mux1/3
  trig_src/1 -> Delay2/1
  valid_src/1 -> Delay3/1
  Constant/1 -> Register1/1
  Register1/1 -> Register6/3
  Logical/1 -> Register1/2
  stopi/1 -> stop/1

== system roach2_tut_corr/snap_adc2/bram ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_snap_adc2_bram_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc2_bram_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_snap_adc2_bram_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_snap_adc2_bram_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_snap_adc2_bram_addr/1
  convert_din1/1 -> roach2_tut_corr_snap_adc2_bram_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_snap_adc2_bram_we/1 -> mem/3(In3)
  roach2_tut_corr_snap_adc2_bram_data_in/1 -> mem/2(In2)
  roach2_tut_corr_snap_adc2_bram_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_snap_adc2_bram_we/1
  roach2_tut_corr_snap_adc2_bram_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_snap_adc2_bram_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/snap_adc2/ctrl ==
  sim_1 : Inport
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc2_ctrl_user_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  slice_reg : xbsIndex_r4/Slice  nbits=32  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  in_reg : Outport
  wires:
  roach2_tut_corr_snap_adc2_ctrl_user_data_out/1 -> io_delay/1
  sim_1/1 -> roach2_tut_corr_snap_adc2_ctrl_user_data_out/1
  io_delay/1 -> slice_reg/1
  slice_reg/1 -> reint1/1
  reint1/1 -> in_reg/1

== system roach2_tut_corr/snap_adc2/status ==
  out_reg : Inport
  assert_reg : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  cast_gw : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  roach2_tut_corr_snap_adc2_status_user_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_out : Outport
  wires:
  io_delay/1 -> cast_gw/1
  cast_gw/1 -> roach2_tut_corr_snap_adc2_status_user_data_in/1
  roach2_tut_corr_snap_adc2_status_user_data_in/1 -> sim_out/1
  out_reg/1 -> assert_reg/1
  assert_reg/1 -> reint1/1
  reint1/1 -> io_delay/1
