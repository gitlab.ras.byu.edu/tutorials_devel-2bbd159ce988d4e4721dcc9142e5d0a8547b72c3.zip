simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 71 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/munge/split ==
  bus_in : Inport
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-14  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-12  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-10  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-8  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-6  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-4  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out8 : Outport
  out7 : Outport  Port=2
  out6 : Outport  Port=3
  out5 : Outport  Port=4
  out4 : Outport  Port=5
  out3 : Outport  Port=6
  out2 : Outport  Port=7
  lsb_out1 : Outport  Port=8
  wires:
  bus_in/1 -> slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> msb_out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/mux/d_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  concatenate : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/mux/expand0 ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-300  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-120  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-100  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-80  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-60  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-40  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-20  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-280  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-260  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-240  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-220  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-200  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-180  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-160  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-140  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/mux/expand1 ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-300  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-120  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-100  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-80  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-60  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-40  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-20  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-280  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-260  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-240  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-220  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-200  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-180  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-160  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=20  boolean_output=off  mode=Upper Bit Location + Width  bit1=-140  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/mux/sel_expand ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-15  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-6  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-5  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-4  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-3  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-14  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-13  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-12  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-11  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-10  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-9  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-8  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-7  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct/shift_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  concatenate : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay0/rep_addr/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay0/rep_we/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay1/rep_addr/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay1/rep_we/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_add/a_debus ==
  bus_in : Inport
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out8 : Outport
  out7 : Outport  Port=2
  out6 : Outport  Port=3
  out5 : Outport  Port=4
  out4 : Outport  Port=5
  out3 : Outport  Port=6
  out2 : Outport  Port=7
  lsb_out1 : Outport  Port=8
  wires:
  bus_in/1 -> slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> msb_out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_add/b_debus ==
  bus_in : Inport
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out8 : Outport
  out7 : Outport  Port=2
  out6 : Outport  Port=3
  out5 : Outport  Port=4
  out4 : Outport  Port=5
  out3 : Outport  Port=6
  out2 : Outport  Port=7
  lsb_out1 : Outport  Port=8
  wires:
  bus_in/1 -> slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> msb_out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_add/op_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  concatenate : xbsIndex_r4/Concat  num_inputs=8  dbl_ovrd=off  block_type=concat
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  concatenate : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv1 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv10 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv11 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv12 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv13 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv14 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv15 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv16 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv2 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv3 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv4 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct/bus_convert/conv5 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1
