simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 17 of 116)

== system roach2_tut_corr/dir_x1/cd/cmult_dsp48e ==
  a_re : Inport
  a_im : Inport  Port=2
  b_re : Inport  Port=3
  b_im : Inport  Port=4
  Convert{,1..2,5} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=30  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert{3..4,6..7} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  DSP48E_0 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_1 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_2 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_3 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  Terminator : Terminator
  Terminator1 : Terminator
  alumode0 : xbsIndex_r4/Constant  const=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode2 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode3 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryin{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryinsel{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=3  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  cast_c_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  cast_c_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  opmode0 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode1 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode2 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode3 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  realign_a_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_a_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_b_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_b_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  reinterp_a_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_a_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_c_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  reinterp_c_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  c_re : Outport
  c_im : Outport  Port=2
  wires:
  b_im/1 -> realign_b_im/1
  b_re/1 -> realign_b_re/1
  a_im/1 -> realign_a_im/1
  a_re/1 -> realign_a_re/1
  cast_c_im/1 -> c_im/1
  cast_c_re/1 -> c_re/1
  reinterp_b_im/1 -> Convert3/1, Convert7/1
  reinterp_b_re/1 -> Convert6/1, Convert4/1
  reinterp_a_im/1 -> Convert/1, Convert1/1
  reinterp_a_re/1 -> Convert5/1, Convert2/1
  realign_b_im/1 -> reinterp_b_im/1
  realign_b_re/1 -> reinterp_b_re/1
  realign_a_im/1 -> reinterp_a_im/1
  realign_a_re/1 -> reinterp_a_re/1
  Convert/1 -> DSP48E_3/1
  DSP48E_2/1 -> Terminator/1
  DSP48E_2/2 -> DSP48E_3/3
  opmode3/1 -> DSP48E_3/4
  alumode3/1 -> DSP48E_3/5
  carryin3/1 -> DSP48E_3/6
  carryinsel3/1 -> DSP48E_3/7
  Convert3/1 -> DSP48E_3/2
  Convert2/1 -> DSP48E_2/1
  Convert4/1 -> DSP48E_2/2
  opmode2/1 -> DSP48E_2/3
  alumode2/1 -> DSP48E_2/4
  carryin2/1 -> DSP48E_2/5
  carryinsel2/1 -> DSP48E_2/6
  reinterp_c_re/1 -> cast_c_re/1
  DSP48E_3/1 -> reinterp_c_re/1
  Convert1/1 -> DSP48E_1/1
  DSP48E_0/1 -> Terminator1/1
  DSP48E_0/2 -> DSP48E_1/3
  opmode1/1 -> DSP48E_1/4
  alumode1/1 -> DSP48E_1/5
  carryin1/1 -> DSP48E_1/6
  carryinsel1/1 -> DSP48E_1/7
  Convert6/1 -> DSP48E_1/2
  Convert5/1 -> DSP48E_0/1
  Convert7/1 -> DSP48E_0/2
  opmode0/1 -> DSP48E_0/3
  alumode0/1 -> DSP48E_0/4
  carryin0/1 -> DSP48E_0/5
  carryinsel0/1 -> DSP48E_0/6
  DSP48E_1/1 -> reinterp_c_im/1
  reinterp_c_im/1 -> cast_c_im/1

== system roach2_tut_corr/dir_x1/cd/imag ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_dir_x1_cd_imag_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_cd_imag_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_cd_imag_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_dir_x1_cd_imag_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_dir_x1_cd_imag_addr/1
  convert_din1/1 -> roach2_tut_corr_dir_x1_cd_imag_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_dir_x1_cd_imag_we/1 -> mem/3(In3)
  roach2_tut_corr_dir_x1_cd_imag_data_in/1 -> mem/2(In2)
  roach2_tut_corr_dir_x1_cd_imag_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_dir_x1_cd_imag_we/1
  roach2_tut_corr_dir_x1_cd_imag_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_dir_x1_cd_imag_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/dir_x1/cd/real ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_dir_x1_cd_real_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_cd_real_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_cd_real_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_dir_x1_cd_real_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_dir_x1_cd_real_addr/1
  convert_din1/1 -> roach2_tut_corr_dir_x1_cd_real_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_dir_x1_cd_real_we/1 -> mem/3(In3)
  roach2_tut_corr_dir_x1_cd_real_data_in/1 -> mem/2(In2)
  roach2_tut_corr_dir_x1_cd_real_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_dir_x1_cd_real_we/1
  roach2_tut_corr_dir_x1_cd_real_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_dir_x1_cd_real_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/dir_x1/cd/vacc_0 ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem
  pulse_ext : Subsystem
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  delay_bram/1(Out1) -> Mux0/2, dout/1
  Adder0/1 -> delay_bram/1(In1)
  new_acc/1 -> pulse_ext/1(in)
  din/1 -> Adder0/1
  pulse_ext/1(out) -> valid/1, Mux0/1
  Mux0/1 -> Adder0/2
  zero/1 -> Mux0/3

== system roach2_tut_corr/dir_x1/cd/vacc_1 ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem
  pulse_ext : Subsystem
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  zero/1 -> Mux0/3
  Mux0/1 -> Adder0/2
  pulse_ext/1(out) -> Mux0/1, valid/1
  din/1 -> Adder0/1
  new_acc/1 -> pulse_ext/1(in)
  Adder0/1 -> delay_bram/1(In1)
  delay_bram/1(Out1) -> dout/1, Mux0/2

== system roach2_tut_corr/dir_x1/dd/c_to_ri ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1

== system roach2_tut_corr/dir_x1/dd/c_to_ri1 ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1

== system roach2_tut_corr/dir_x1/dd/cmult_dsp48e ==
  a_re : Inport
  a_im : Inport  Port=2
  b_re : Inport  Port=3
  b_im : Inport  Port=4
  Convert{,1..2,5} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=30  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert{3..4,6..7} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  DSP48E_0 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_1 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_2 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_3 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  Terminator : Terminator
  Terminator1 : Terminator
  alumode0 : xbsIndex_r4/Constant  const=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode2 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode3 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryin{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryinsel{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=3  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  cast_c_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  cast_c_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  opmode0 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode1 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode2 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode3 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  realign_a_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_a_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_b_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  realign_b_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  reinterp_a_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_a_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_c_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  reinterp_c_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  c_re : Outport
  c_im : Outport  Port=2
  wires:
  b_im/1 -> realign_b_im/1
  b_re/1 -> realign_b_re/1
  a_im/1 -> realign_a_im/1
  a_re/1 -> realign_a_re/1
  cast_c_im/1 -> c_im/1
  cast_c_re/1 -> c_re/1
  reinterp_b_im/1 -> Convert3/1, Convert7/1
  reinterp_b_re/1 -> Convert6/1, Convert4/1
  reinterp_a_im/1 -> Convert/1, Convert1/1
  reinterp_a_re/1 -> Convert5/1, Convert2/1
  realign_b_im/1 -> reinterp_b_im/1
  realign_b_re/1 -> reinterp_b_re/1
  realign_a_im/1 -> reinterp_a_im/1
  realign_a_re/1 -> reinterp_a_re/1
  Convert/1 -> DSP48E_3/1
  DSP48E_2/1 -> Terminator/1
  DSP48E_2/2 -> DSP48E_3/3
  opmode3/1 -> DSP48E_3/4
  alumode3/1 -> DSP48E_3/5
  carryin3/1 -> DSP48E_3/6
  carryinsel3/1 -> DSP48E_3/7
  Convert3/1 -> DSP48E_3/2
  Convert2/1 -> DSP48E_2/1
  Convert4/1 -> DSP48E_2/2
  opmode2/1 -> DSP48E_2/3
  alumode2/1 -> DSP48E_2/4
  carryin2/1 -> DSP48E_2/5
  carryinsel2/1 -> DSP48E_2/6
  reinterp_c_re/1 -> cast_c_re/1
  DSP48E_3/1 -> reinterp_c_re/1
  Convert1/1 -> DSP48E_1/1
  DSP48E_0/1 -> Terminator1/1
  DSP48E_0/2 -> DSP48E_1/3
  opmode1/1 -> DSP48E_1/4
  alumode1/1 -> DSP48E_1/5
  carryin1/1 -> DSP48E_1/6
  carryinsel1/1 -> DSP48E_1/7
  Convert6/1 -> DSP48E_1/2
  Convert5/1 -> DSP48E_0/1
  Convert7/1 -> DSP48E_0/2
  opmode0/1 -> DSP48E_0/3
  alumode0/1 -> DSP48E_0/4
  carryin0/1 -> DSP48E_0/5
  carryinsel0/1 -> DSP48E_0/6
  DSP48E_1/1 -> reinterp_c_im/1
  reinterp_c_im/1 -> cast_c_im/1

== system roach2_tut_corr/dir_x1/dd/real ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_dir_x1_dd_real_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_dd_real_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_dir_x1_dd_real_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_dir_x1_dd_real_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_dir_x1_dd_real_addr/1
  convert_din1/1 -> roach2_tut_corr_dir_x1_dd_real_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_dir_x1_dd_real_we/1 -> mem/3(In3)
  roach2_tut_corr_dir_x1_dd_real_data_in/1 -> mem/2(In2)
  roach2_tut_corr_dir_x1_dd_real_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_dir_x1_dd_real_we/1
  roach2_tut_corr_dir_x1_dd_real_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_dir_x1_dd_real_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/dir_x1/dd/vacc_32bit ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem
  pulse_ext : Subsystem
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  Adder0/1 -> delay_bram/1(In1)
  delay_bram/1(Out1) -> dout/1, Mux0/2
  new_acc/1 -> pulse_ext/1(in)
  din/1 -> Adder0/1
  pulse_ext/1(out) -> valid/1, Mux0/1
  Mux0/1 -> Adder0/2
  zero/1 -> Mux0/3

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x ==
  sync : Inport
  even : Inport  Port=2
  odd : Inport  Port=3
  c0 : xbsIndex_r4/Constant  const=2^(FFTSize-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  c1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  count : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  d{0,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  d2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency + conv_latency + 1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay0 : Subsystem  AncestorBlock=casper_library_delays/delay_bram
  delay1 : Subsystem  AncestorBlock=casper_library_delays/delay_bram
  en_even : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  en_odd : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  en_out : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  hilbert0 : Subsystem  AncestorBlock=casper_library_ffts_internal/hilbert
  hilbert1 : Subsystem  AncestorBlock=casper_library_ffts_internal/hilbert
  mirror_spectrum : Subsystem  AncestorBlock=casper_library_ffts_internal/mirror_spectrum
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  r0 : xbsIndex_r4/Relational  mode=a=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  r1 : xbsIndex_r4/Relational  mode=a=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  reorder_even : Subsystem  AncestorBlock=casper_library_reorder/reorder
  reorder_odd : Subsystem  AncestorBlock=casper_library_reorder/reorder
  reorder_out : Subsystem  AncestorBlock=casper_library_reorder/reorder
  sync_delay : Subsystem  AncestorBlock=casper_library_delays/sync_delay
  t{0..4} (5 alike) : Terminator
  sync_out : Outport
  pol1_out : Outport  Port=2
  pol2_out : Outport  Port=3
  pol3_out : Outport  Port=4
  pol4_out : Outport  Port=5
  wires:
  even/1 -> reorder_even/3(din0)
  sync/1 -> reorder_even/1(sync), reorder_odd/1(sync)
  odd/1 -> reorder_odd/3(din0)
  reorder_odd/1(sync_out) -> t0/1
  reorder_odd/2(valid) -> t1/1
  reorder_even/2(valid) -> t2/1
  en_even/1 -> reorder_even/2(en)
  en_odd/1 -> reorder_odd/2(en)
  c0/1 -> r0/1
  count/1 -> r0/2, r1/1
  c1/1 -> r1/2
  reorder_odd/3(dout0) -> d0/1
  reorder_even/1(sync_out) -> count/1, d2/1
  r0/1 -> mux0/1, mux3/1
  r1/1 -> mux1/1, mux2/1
  reorder_even/3(dout0) -> mux0/2, mux1/3, mux2/2, mux3/3
  d0/1 -> mux0/3, mux1/2, mux2/3, mux3/2
  d2/1 -> sync_delay/1(In)
  mux0/1 -> hilbert0/1(a)
  mux1/1 -> hilbert0/2(b)
  mux2/1 -> hilbert1/1(a)
  mux3/1 -> hilbert1/2(b)
  hilbert0/1(even) -> delay0/1(din)
  hilbert0/2(odd) -> delay1/1(din)
  delay0/1(dout) -> mirror_spectrum/2(din0), reorder_out/3(din0)
  delay1/1(dout) -> mirror_spectrum/4(din1), reorder_out/4(din1)
  hilbert1/1(even) -> mirror_spectrum/6(din2), reorder_out/5(din2)
  hilbert1/2(odd) -> mirror_spectrum/8(din3), reorder_out/6(din3)
  mirror_spectrum/1(sync_out) -> sync_out/1
  mirror_spectrum/2(dout0) -> pol1_out/1
  mirror_spectrum/3(dout1) -> pol2_out/1
  mirror_spectrum/4(dout2) -> pol3_out/1
  mirror_spectrum/5(dout3) -> pol4_out/1
  sync_delay/1(Out) -> mirror_spectrum/1(sync), reorder_out/1(sync)
  en_out/1 -> reorder_out/2(en)
  reorder_out/1(sync_out) -> t3/1
  reorder_out/2(valid) -> t4/1
  reorder_out/3(dout0) -> d3/1
  d3/1 -> mirror_spectrum/3(reo_in0)
  reorder_out/4(dout1) -> d4/1
  d4/1 -> mirror_spectrum/5(reo_in1)
  reorder_out/5(dout2) -> d5/1
  d5/1 -> mirror_spectrum/7(reo_in2)
  reorder_out/6(dout3) -> d6/1
  d6/1 -> mirror_spectrum/9(reo_in3)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core ==
  sync : Inport
  shift : Inport  Port=2
  pol1 : Inport  Port=3
  pol2 : Inport  Port=4
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  fft_stage_1 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_2 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_3 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_4 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_5 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_6 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_7 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_8 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  fft_stage_9 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n
  sync_out : Outport
  out1 : Outport  Port=2
  out2 : Outport  Port=3
  of : Outport  Port=4
  wires:
  fft_stage_1/1(out1) -> fft_stage_2/1(in1)
  fft_stage_1/2(out2) -> fft_stage_2/2(in2)
  fft_stage_1/3(of) -> fft_stage_2/3(of_in)
  fft_stage_1/4(sync_out) -> fft_stage_2/4(sync)
  shift/1 -> fft_stage_2/5(shift), fft_stage_3/5(shift), fft_stage_4/5(shift), fft_stage_5/5(shift), fft_stage_6/5(shift), fft_stage_7/5(shift), fft_stage_8/5(shift), fft_stage_9/5(shift), fft_stage_1/5(shift)
  fft_stage_2/1(out1) -> fft_stage_3/1(in1)
  fft_stage_2/2(out2) -> fft_stage_3/2(in2)
  fft_stage_2/3(of) -> fft_stage_3/3(of_in)
  fft_stage_2/4(sync_out) -> fft_stage_3/4(sync)
  fft_stage_3/1(out1) -> fft_stage_4/1(in1)
  fft_stage_3/2(out2) -> fft_stage_4/2(in2)
  fft_stage_3/3(of) -> fft_stage_4/3(of_in)
  fft_stage_3/4(sync_out) -> fft_stage_4/4(sync)
  fft_stage_4/1(out1) -> fft_stage_5/1(in1)
  fft_stage_4/2(out2) -> fft_stage_5/2(in2)
  fft_stage_4/3(of) -> fft_stage_5/3(of_in)
  fft_stage_4/4(sync_out) -> fft_stage_5/4(sync)
  fft_stage_5/1(out1) -> fft_stage_6/1(in1)
  fft_stage_5/2(out2) -> fft_stage_6/2(in2)
  fft_stage_5/3(of) -> fft_stage_6/3(of_in)
  fft_stage_5/4(sync_out) -> fft_stage_6/4(sync)
  fft_stage_6/1(out1) -> fft_stage_7/1(in1)
  fft_stage_6/2(out2) -> fft_stage_7/2(in2)
  fft_stage_6/3(of) -> fft_stage_7/3(of_in)
  fft_stage_6/4(sync_out) -> fft_stage_7/4(sync)
  fft_stage_7/1(out1) -> fft_stage_8/1(in1)
  fft_stage_7/2(out2) -> fft_stage_8/2(in2)
  fft_stage_7/3(of) -> fft_stage_8/3(of_in)
  fft_stage_7/4(sync_out) -> fft_stage_8/4(sync)
  fft_stage_8/1(out1) -> fft_stage_9/1(in1)
  fft_stage_8/2(out2) -> fft_stage_9/2(in2)
  fft_stage_8/3(of) -> fft_stage_9/3(of_in)
  fft_stage_8/4(sync_out) -> fft_stage_9/4(sync)
  pol1/1 -> fft_stage_1/1(in1)
  pol2/1 -> fft_stage_1/2(in2)
  Constant/1 -> fft_stage_1/3(of_in)
  sync/1 -> fft_stage_1/4(sync)
  fft_stage_9/1(out1) -> out1/1
  fft_stage_9/2(out2) -> out2/1
  fft_stage_9/3(of) -> of/1
  fft_stage_9/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/even_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  concatenate : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/odd_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  concatenate : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
