simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 6 of 116)

== system roach2_tut_corr/quant1/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant2/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/quant2/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_quant2_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant2_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant2_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_quant2_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_quant2_coeffs_addr/1
  convert_din1/1 -> roach2_tut_corr_quant2_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_quant2_coeffs_we/1 -> mem/3(In3)
  roach2_tut_corr_quant2_coeffs_data_in/1 -> mem/2(In2)
  roach2_tut_corr_quant2_coeffs_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_quant2_coeffs_we/1
  roach2_tut_corr_quant2_coeffs_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_quant2_coeffs_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/quant2/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant2/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant3/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/quant3/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_quant3_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant3_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant3_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_quant3_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_quant3_coeffs_addr/1
  convert_din1/1 -> roach2_tut_corr_quant3_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_quant3_coeffs_we/1 -> mem/3(In3)
  roach2_tut_corr_quant3_coeffs_data_in/1 -> mem/2(In2)
  roach2_tut_corr_quant3_coeffs_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_quant3_coeffs_we/1
  roach2_tut_corr_quant3_coeffs_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_quant3_coeffs_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/quant3/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant3/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/snap_adc0/add_gen ==
  note: To storage
  note: prevent one extra write to address 0
  note: Do one capture by default
  note: Count of bytes in BRAM as well as done signal
  note: A total count of bytes written to BRAM since trig
  note: Force MSbit of count to be '1' by negating busy as counter bit may be '0' or '1'
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  go : Inport  Port=4
  cont : Inport  Port=5
  init : Inport  Port=6
  Concat : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  Convert : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32-nsamples-log2(increment)-1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  Delay{,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay7 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=1  dbl_ovrd=off  block_type=inv
  Inverter1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical1 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical2 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical4 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical6 : xbsIndex_r4/Logical  logical_function=AND  inputs=3  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Register3 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register4 : xbsIndex_r4/Register  init=0  rst=off  en=on  dbl_ovrd=off  block_type=register
  Register5 : xbsIndex_r4/Register  init=1  rst=on  en=on  dbl_ovrd=off  block_type=register
  Shift : xbsIndex_r4/Shift  shift_dir=Left  shift_bits=32-nsamples-log2(increment)-1-1  en=off  latency=1  precision=Full  arith_type="Signed  (2's comp)"  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=shift
  add_gen : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1  operation=Up  start_count=0  cnt_by_val=increment  arith_type=Unsigned  n_bits=counter_size  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=DSP48  use_rpm=on  block_type=counter
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect
  slice1 : xbsIndex_r4/Slice  nbits=nsamples+log2(increment)  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=nsamples-burst_size  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=log2(increment)+burst_size  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=nsamples + log2(increment)  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  add : Outport  Port=2
  dout : Outport  Port=3
  we_o : Outport  Port=4
  status : Outport  Port=5
  en_cnt : Outport  Port=6
  wires:
  Shift/1 -> Concat/1
  Delay/1 -> Register5/2
  Inverter1/1 -> Logical4/2
  cont/1 -> Delay3/1
  edge_detect/1(out) -> Inverter1/1, Register5/3
  Register4/1 -> vout/1
  Logical2/1 -> Register4/2
  Register3/1 -> Logical2/2
  vin/1 -> Delay5/1
  add_gen/1 -> slice2/1, slice1/1, Delay2/1, slice3/1
  Register5/1 -> Convert/1, Inverter/1, Logical6/1
  slice3/1 -> edge_detect/1(in)
  init/1 -> Delay4/1
  Logical6/1 -> we_o/1, Logical2/1, Register3/2, add_gen/2
  Concat/1 -> status/1
  Convert/1 -> Shift/1
  slice2/1 -> add/1
  Delay2/1 -> en_cnt/1
  din/1 -> Delay6/1
  Delay1/1 -> Concat/3
  slice1/1 -> Delay1/1
  Inverter/1 -> Concat/2
  Logical4/1 -> Logical6/2
  we/1 -> Logical1/1
  go/1 -> Logical1/2
  Logical1/1 -> Logical6/3
  Delay7/1 -> Register4/1
  Delay3/1 -> Logical4/1, Register5/1
  Delay4/1 -> Register3/3, Register3/1, add_gen/1, Delay/1
  Delay5/1 -> Delay7/1
  Delay6/1 -> dout/1
