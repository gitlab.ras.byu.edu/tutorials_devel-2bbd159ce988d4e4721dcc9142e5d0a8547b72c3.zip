simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 5 of 116)

== system roach2_tut_corr/pfb_fir_generic/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..16} (16 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> scale1/1
  debus/2(out15) -> scale2/1
  debus/3(out14) -> scale3/1
  debus/4(out13) -> scale4/1
  debus/5(out12) -> scale5/1
  debus/6(out11) -> scale6/1
  debus/7(out10) -> scale7/1
  debus/8(out9) -> scale8/1
  debus/9(out8) -> scale9/1
  debus/10(out7) -> scale10/1
  debus/11(out6) -> scale11/1
  debus/12(out5) -> scale12/1
  debus/13(out4) -> scale13/1
  debus/14(out3) -> scale14/1
  debus/15(out2) -> scale15/1
  debus/16(lsb_out1) -> scale16/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/pfb_fir_generic/coeff_munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/13(out4) -> join/1(in1), join/2(in2), join/3(in3), join/4(in4)
  split/14(out3) -> join/5(in5), join/6(in6), join/7(in7), join/8(in8)
  split/15(out2) -> join/9(in9), join/10(in10), join/11(in11), join/12(in12)
  split/16(lsb_out1) -> join/13(in13), join/14(in14), join/15(in15), join/16(in16)
  split/9(out8) -> join/17(in17), join/18(in18), join/19(in19), join/20(in20)
  split/10(out7) -> join/21(in21), join/22(in22), join/23(in23), join/24(in24)
  split/11(out6) -> join/25(in25), join/26(in26), join/27(in27), join/28(in28)
  split/12(out5) -> join/29(in29), join/30(in30), join/31(in31), join/32(in32)
  split/5(out12) -> join/33(in33), join/34(in34), join/35(in35), join/36(in36)
  split/6(out11) -> join/37(in37), join/38(in38), join/39(in39), join/40(in40)
  split/7(out10) -> join/41(in41), join/42(in42), join/43(in43), join/44(in44)
  split/8(out9) -> join/45(in45), join/46(in46), join/47(in47), join/48(in48)
  split/1(msb_out16) -> join/49(in49), join/50(in50), join/51(in51), join/52(in52)
  split/2(out15) -> join/53(in53), join/54(in54), join/55(in55), join/56(in56)
  split/3(out14) -> join/57(in57), join/58(in58), join/59(in59), join/60(in60)
  split/4(out13) -> join/61(in61), join/62(in62), join/63(in63), join/64(in64)

== system roach2_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen ==
  sync : Inport
  din : Inport  Port=2
  a_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  b_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  concat : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  const0 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=18  bin_pt=17  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  const1 : xbsIndex_r4/Constant  const=2.104e-17  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=18  bin_pt=17  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  block_type=counter
  d{0..15} (16 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dfirst : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  first : xbsIndex_r4/Relational  mode=a=b  en=off  latency=1  dbl_ovrd=off  block_type=relational
  inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  reinterpret0 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  rom : Subsystem  AncestorBlock=casper_library_bus/bus_dual_port_ram
  rom_din : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=144  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  rom_we : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=9  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_out : Outport
  dout : Outport  Port=2
  coeffs : Outport  Port=3
  wires:
  sync/1 -> sync_delay/1, counter/1
  sync_delay/1 -> sync_out/1
  din/1 -> din_delay/1
  din_delay/1 -> dout/1
  counter/1 -> inverter/1, rom/1(addra), first/2
  inverter/1 -> rom/4(addrb)
  rom_din/1 -> rom/2(dina), rom/5(dinb)
  rom_we/1 -> rom/3(wea), rom/6(web)
  zero/1 -> first/1
  first/1 -> dfirst/1
  rom/2(B) -> munge/1(din)
  rom/1(A) -> a_expand/1(bus_in)
  munge/1(dout) -> b_expand/1(bus_in)
  concat/1 -> coeffs/1
  a_expand/1(msb_out8) -> d0/1
  d0/1 -> concat/1
  a_expand/2(out7) -> d1/1
  d1/1 -> concat/2
  a_expand/3(out6) -> d2/1
  d2/1 -> concat/3
  a_expand/4(out5) -> d3/1
  d3/1 -> concat/4
  a_expand/5(out4) -> d4/1
  d4/1 -> concat/5
  a_expand/6(out3) -> d5/1
  d5/1 -> concat/6
  a_expand/7(out2) -> d6/1
  d6/1 -> concat/7
  a_expand/8(lsb_out1) -> d7/1
  d7/1 -> concat/8
  b_expand/1(msb_out8) -> d8/1
  const0/1 -> reinterpret0/1
  reinterpret0/1 -> mux0/3
  dfirst/1 -> mux0/1, mux1/1
  d8/1 -> mux0/2
  mux0/1 -> concat/9
  b_expand/2(out7) -> d9/1
  d9/1 -> concat/10
  b_expand/3(out6) -> d10/1
  d10/1 -> concat/11
  b_expand/4(out5) -> d11/1
  d11/1 -> concat/12
  b_expand/5(out4) -> d12/1
  const1/1 -> reinterpret1/1
  reinterpret1/1 -> mux1/3
  d12/1 -> mux1/2
  mux1/1 -> concat/13
  b_expand/6(out3) -> d13/1
  d13/1 -> concat/14
  b_expand/7(out2) -> d14/1
  d14/1 -> concat/15
  b_expand/8(lsb_out1) -> d15/1
  d15/1 -> concat/16

== system roach2_tut_corr/pfb_fir_generic/pfb_fir_taps ==
  sync : Inport
  din : Inport  Port=2
  coeffs : Inport  Port=3
  always : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  arnold : Terminator
  bram_din : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_adder_tree : Subsystem  AncestorBlock=casper_library_bus/bus_adder_tree
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  block_type=counter
  daddr : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dcoeffs : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  mult_din : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  never : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_delay : casper_library_delays/sync_delay  DelayLen=(2^(pfb_size-n_inputs))*(n_taps-1)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,d7318e4b,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  tap_delays : Subsystem  AncestorBlock=casper_library_bus/bus_dual_port_ram
  tap_split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  youngest : xbsIndex_r4/Slice  nbits=(1*n_bits_data)*(n_taps-2)*(2^n_inputs)*n_streams  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  dsync0/1 -> dsync1/1
  dsync1/1 -> dsync2/1
  dsync2/1 -> sync_out/1
  din/1 -> ddin/1
  coeffs/1 -> dcoeffs/1
  sync/1 -> sync_delay/1, counter/1
  sync_delay/1 -> dsync0/1
  ddin/1 -> bram_din/1, mult_din/1
  youngest/1 -> bram_din/2
  counter/1 -> daddr/1, tap_delays/1(addra)
  bram_din/1 -> tap_delays/2(dina), tap_delays/5(dinb)
  never/1 -> tap_delays/3(wea)
  daddr/1 -> tap_delays/4(addrb)
  always/1 -> tap_delays/6(web)
  tap_delays/2(B) -> arnold/1
  tap_delays/1(A) -> mult_din/2, youngest/1
  mult_din/1 -> bus_mult/1(a)
  dcoeffs/1 -> bus_mult/2(b)
  bus_mult/1(a*b) -> tap_split/1(bus_in)
  tap_split/1(msb_out4) -> bus_adder_tree/1(d0)
  tap_split/2(out3) -> bus_adder_tree/2(d1)
  tap_split/3(out2) -> bus_adder_tree/3(d2)
  tap_split/4(lsb_out1) -> bus_adder_tree/4(d3)
  bus_adder_tree/1(out) -> dout/1

== system roach2_tut_corr/pulse_ext2/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/pulse_ext6/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/quant0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/quant0/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_quant0_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant0_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant0_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_quant0_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_quant0_coeffs_addr/1
  convert_din1/1 -> roach2_tut_corr_quant0_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_quant0_coeffs_we/1 -> mem/3(In3)
  roach2_tut_corr_quant0_coeffs_data_in/1 -> mem/2(In2)
  roach2_tut_corr_quant0_coeffs_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_quant0_coeffs_we/1
  roach2_tut_corr_quant0_coeffs_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_quant0_coeffs_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/quant0/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant0/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system roach2_tut_corr/quant1/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/quant1/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  calc_add : Subsystem
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  mem : Subsystem
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  roach2_tut_corr_quant1_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant1_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  roach2_tut_corr_quant1_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  roach2_tut_corr_quant1_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'A14'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  data_out : Outport
  wires:
  convert_addr/1 -> roach2_tut_corr_quant1_coeffs_addr/1
  convert_din1/1 -> roach2_tut_corr_quant1_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> convert_addr/1
  roach2_tut_corr_quant1_coeffs_we/1 -> mem/3(In3)
  roach2_tut_corr_quant1_coeffs_data_in/1 -> mem/2(In2)
  roach2_tut_corr_quant1_coeffs_addr/1 -> mem/1(In1)
  convert_we/1 -> roach2_tut_corr_quant1_coeffs_we/1
  roach2_tut_corr_quant1_coeffs_data_out/1 -> munge_out/1(din)
  mem/1(Out1) -> roach2_tut_corr_quant1_coeffs_data_out/1
  addr/1 -> calc_add/1(in)
  we/1 -> convert_we/1
  munge_out/1(dout) -> data_out/1
  munge_in/1(dout) -> convert_din1/1

== system roach2_tut_corr/quant1/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  dbl_ovrd=off  pipeline=on  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  dbl_ovrd=off  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2
