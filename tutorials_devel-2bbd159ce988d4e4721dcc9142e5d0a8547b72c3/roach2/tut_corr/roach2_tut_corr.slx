simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 30 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=144  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=144  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv{1..16} (16 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1
  debus/2(out15) -> conv2/1
  debus/3(out14) -> conv3/1
  debus/4(out13) -> conv4/1
  debus/5(out12) -> conv5/1
  debus/6(out11) -> conv6/1
  debus/7(out10) -> conv7/1
  debus/8(out9) -> conv8/1
  debus/9(out8) -> conv9/1
  debus/10(out7) -> conv10/1
  debus/11(out6) -> conv11/1
  debus/12(out5) -> conv12/1
  debus/13(out4) -> conv13/1
  debus/14(out3) -> conv14/1
  debus/15(out2) -> conv15/1
  debus/16(lsb_out1) -> conv16/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  conv13/1 -> bussify/13(in13)
  conv14/1 -> bussify/14(in14)
  conv15/1 -> bussify/15(in15)
  conv16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(in)
  debus/2(out15) -> conv2/1(in)
  debus/3(out14) -> conv3/1(in)
  debus/4(out13) -> conv4/1(in)
  debus/5(out12) -> conv5/1(in)
  debus/6(out11) -> conv6/1(in)
  debus/7(out10) -> conv7/1(in)
  debus/8(out9) -> conv8/1(in)
  debus/9(out8) -> conv9/1(in)
  debus/10(out7) -> conv10/1(in)
  debus/11(out6) -> conv11/1(in)
  debus/12(out5) -> conv12/1(in)
  debus/13(out4) -> conv13/1(in)
  debus/14(out3) -> conv14/1(in)
  debus/15(out2) -> conv15/1(in)
  debus/16(lsb_out1) -> conv16/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  relational{1..4} (4 alike) : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1, relational4/1
  b_debus/1(msb_out4) -> relational1/2
  b_debus/2(out3) -> relational2/2
  b_debus/3(out2) -> relational3/2
  b_debus/4(lsb_out1) -> relational4/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  relational4/1 -> bussify/4(in4)
  bussify/1(bus_out) -> a!=b/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..16} (16 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> scale1/1
  debus/2(out15) -> scale2/1
  debus/3(out14) -> scale3/1
  debus/4(out13) -> scale4/1
  debus/5(out12) -> scale5/1
  debus/6(out11) -> scale6/1
  debus/7(out10) -> scale7/1
  debus/8(out9) -> scale8/1
  debus/9(out8) -> scale9/1
  debus/10(out7) -> scale10/1
  debus/11(out6) -> scale11/1
  debus/12(out5) -> scale12/1
  debus/13(out4) -> scale13/1
  debus/14(out3) -> scale14/1
  debus/15(out2) -> scale15/1
  debus/16(lsb_out1) -> scale16/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..8} (8 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out8) -> addsub1/1
  b_debus/1(msb_out8) -> addsub1/2
  a_debus/2(out7) -> addsub2/1
  b_debus/2(out7) -> addsub2/2
  a_debus/3(out6) -> addsub3/1
  b_debus/3(out6) -> addsub3/2
  a_debus/4(out5) -> addsub4/1
  b_debus/4(out5) -> addsub4/2
  a_debus/5(out4) -> addsub5/1
  b_debus/5(out4) -> addsub5/2
  a_debus/6(out3) -> addsub6/1
  b_debus/6(out3) -> addsub6/2
  a_debus/7(out2) -> addsub7/1
  b_debus/7(out2) -> addsub7/2
  a_debus/8(lsb_out1) -> addsub8/1
  b_debus/8(lsb_out1) -> addsub8/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/mux ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..15} (16 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out16) -> mux0/1
  expand0/1(msb_out16) -> mux0/2
  expand1/1(msb_out16) -> mux0/3
  sel_expand/2(out15) -> mux1/1
  expand0/2(out15) -> mux1/2
  expand1/2(out15) -> mux1/3
  sel_expand/3(out14) -> mux2/1
  expand0/3(out14) -> mux2/2
  expand1/3(out14) -> mux2/3
  sel_expand/4(out13) -> mux3/1
  expand0/4(out13) -> mux3/2
  expand1/4(out13) -> mux3/3
  sel_expand/5(out12) -> mux4/1
  expand0/5(out12) -> mux4/2
  expand1/5(out12) -> mux4/3
  sel_expand/6(out11) -> mux5/1
  expand0/6(out11) -> mux5/2
  expand1/6(out11) -> mux5/3
  sel_expand/7(out10) -> mux6/1
  expand0/7(out10) -> mux6/2
  expand1/7(out10) -> mux6/3
  sel_expand/8(out9) -> mux7/1
  expand0/8(out9) -> mux7/2
  expand1/8(out9) -> mux7/3
  sel_expand/9(out8) -> mux8/1
  expand0/9(out8) -> mux8/2
  expand1/9(out8) -> mux8/3
  sel_expand/10(out7) -> mux9/1
  expand0/10(out7) -> mux9/2
  expand1/10(out7) -> mux9/3
  sel_expand/11(out6) -> mux10/1
  expand0/11(out6) -> mux10/2
  expand1/11(out6) -> mux10/3
  sel_expand/12(out5) -> mux11/1
  expand0/12(out5) -> mux11/2
  expand1/12(out5) -> mux11/3
  sel_expand/13(out4) -> mux12/1
  expand0/13(out4) -> mux12/2
  expand1/13(out4) -> mux12/3
  sel_expand/14(out3) -> mux13/1
  expand0/14(out3) -> mux13/2
  expand1/14(out3) -> mux13/3
  sel_expand/15(out2) -> mux14/1
  expand0/15(out2) -> mux14/2
  expand1/15(out2) -> mux14/3
  sel_expand/16(lsb_out1) -> mux15/1
  expand0/16(lsb_out1) -> mux15/2
  expand1/16(lsb_out1) -> mux15/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  mux4/1 -> d_bussify/5(in5)
  mux5/1 -> d_bussify/6(in6)
  mux6/1 -> d_bussify/7(in7)
  mux7/1 -> d_bussify/8(in8)
  mux8/1 -> d_bussify/9(in9)
  mux9/1 -> d_bussify/10(in10)
  mux10/1 -> d_bussify/11(in11)
  mux11/1 -> d_bussify/12(in12)
  mux12/1 -> d_bussify/13(in13)
  mux13/1 -> d_bussify/14(in14)
  mux14/1 -> d_bussify/15(in15)
  mux15/1 -> d_bussify/16(in16)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/shift_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_{0..15} (16 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1, din0_4/1, din0_5/1, din0_6/1, din0_7/1, din0_8/1, din0_9/1, din0_10/1, din0_11/1, din0_12/1, din0_13/1, din0_14/1, din0_15/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  din0_2/1 -> bussify/3(in3)
  din0_3/1 -> bussify/4(in4)
  din0_4/1 -> bussify/5(in5)
  din0_5/1 -> bussify/6(in6)
  din0_6/1 -> bussify/7(in7)
  din0_7/1 -> bussify/8(in8)
  din0_8/1 -> bussify/9(in9)
  din0_9/1 -> bussify/10(in10)
  din0_10/1 -> bussify/11(in11)
  din0_11/1 -> bussify/12(in12)
  din0_12/1 -> bussify/13(in13)
  din0_13/1 -> bussify/14(in14)
  din0_14/1 -> bussify/15(in15)
  din0_15/1 -> bussify/16(in16)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/twiddle ==
  ai : Inport
  bi : Inport  Port=2
  sync_in : Inport  Port=3
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult
  coeff_gen : Subsystem  AncestorBlock=casper_library_ffts_twiddle_coeff_gen/coeff_gen
  ao : Outport
  bwo : Outport  Port=2
  sync_out : Outport  Port=3
  wires:
  bi/1 -> bus_create/1(in1)
  sync_in/1 -> bus_create/2(in2), coeff_gen/1(rst)
  ai/1 -> bus_create/3(in3)
  bus_create/1(bus_out) -> coeff_gen/2(misci)
  coeff_gen/2(misco) -> bus_expand/1(bus_in)
  coeff_gen/1(w) -> bus_mult/1(a)
  bus_expand/2(lsb_out1) -> bus_mult/3(misci)
  bus_expand/1(msb_out2) -> bus_mult/2(b)
  bus_mult/1(a*b) -> bus_convert/1(din)
  bus_mult/2(misco) -> bus_convert/2(misci)
  bus_convert/1(dout) -> bwo/1
  bus_convert/2(misco) -> bus_expand1/1(bus_in)
  bus_expand1/1(msb_out2) -> sync_out/1
  bus_expand1/2(lsb_out1) -> ao/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_add ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..8} (8 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out8) -> addsub1/1
  b_debus/1(msb_out8) -> addsub1/2
  a_debus/2(out7) -> addsub2/1
  b_debus/2(out7) -> addsub2/2
  a_debus/3(out6) -> addsub3/1
  b_debus/3(out6) -> addsub3/2
  a_debus/4(out5) -> addsub4/1
  b_debus/4(out5) -> addsub4/2
  a_debus/5(out4) -> addsub5/1
  b_debus/5(out4) -> addsub5/2
  a_debus/6(out3) -> addsub6/1
  b_debus/6(out3) -> addsub6/2
  a_debus/7(out2) -> addsub7/1
  b_debus/7(out2) -> addsub7/2
  a_debus/8(lsb_out1) -> addsub8/1
  b_debus/8(lsb_out1) -> addsub8/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(din)
  debus/2(out15) -> conv2/1(din)
  debus/3(out14) -> conv3/1(din)
  debus/4(out13) -> conv4/1(din)
  debus/5(out12) -> conv5/1(din)
  debus/6(out11) -> conv6/1(din)
  debus/7(out10) -> conv7/1(din)
  debus/8(out9) -> conv8/1(din)
  debus/9(out8) -> conv9/1(din)
  debus/10(out7) -> conv10/1(din)
  debus/11(out6) -> conv11/1(din)
  debus/12(out5) -> conv12/1(din)
  debus/13(out4) -> conv13/1(din)
  debus/14(out3) -> conv14/1(din)
  debus/15(out2) -> conv15/1(din)
  debus/16(lsb_out1) -> conv16/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv13/1(dout) -> bussify/13(in13)
  conv14/1(dout) -> bussify/14(in14)
  conv15/1(dout) -> bussify/15(in15)
  conv16/1(dout) -> bussify/16(in16)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  conv13/2(of) -> of_bussify/13(in13)
  conv14/2(of) -> of_bussify/14(in14)
  conv15/2(of) -> of_bussify/15(in15)
  conv16/2(of) -> of_bussify/16(in16)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=144  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=144  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv{1..16} (16 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1
  debus/2(out15) -> conv2/1
  debus/3(out14) -> conv3/1
  debus/4(out13) -> conv4/1
  debus/5(out12) -> conv5/1
  debus/6(out11) -> conv6/1
  debus/7(out10) -> conv7/1
  debus/8(out9) -> conv8/1
  debus/9(out8) -> conv9/1
  debus/10(out7) -> conv10/1
  debus/11(out6) -> conv11/1
  debus/12(out5) -> conv12/1
  debus/13(out4) -> conv13/1
  debus/14(out3) -> conv14/1
  debus/15(out2) -> conv15/1
  debus/16(lsb_out1) -> conv16/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  conv13/1 -> bussify/13(in13)
  conv14/1 -> bussify/14(in14)
  conv15/1 -> bussify/15(in15)
  conv16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(in)
  debus/2(out15) -> conv2/1(in)
  debus/3(out14) -> conv3/1(in)
  debus/4(out13) -> conv4/1(in)
  debus/5(out12) -> conv5/1(in)
  debus/6(out11) -> conv6/1(in)
  debus/7(out10) -> conv7/1(in)
  debus/8(out9) -> conv8/1(in)
  debus/9(out8) -> conv9/1(in)
  debus/10(out7) -> conv10/1(in)
  debus/11(out6) -> conv11/1(in)
  debus/12(out5) -> conv12/1(in)
  debus/13(out4) -> conv13/1(in)
  debus/14(out3) -> conv14/1(in)
  debus/15(out2) -> conv15/1(in)
  debus/16(lsb_out1) -> conv16/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  relational{1..4} (4 alike) : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1, relational4/1
  b_debus/1(msb_out4) -> relational1/2
  b_debus/2(out3) -> relational2/2
  b_debus/3(out2) -> relational3/2
  b_debus/4(lsb_out1) -> relational4/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  relational4/1 -> bussify/4(in4)
  bussify/1(bus_out) -> a!=b/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..16} (16 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> scale1/1
  debus/2(out15) -> scale2/1
  debus/3(out14) -> scale3/1
  debus/4(out13) -> scale4/1
  debus/5(out12) -> scale5/1
  debus/6(out11) -> scale6/1
  debus/7(out10) -> scale7/1
  debus/8(out9) -> scale8/1
  debus/9(out8) -> scale9/1
  debus/10(out7) -> scale10/1
  debus/11(out6) -> scale11/1
  debus/12(out5) -> scale12/1
  debus/13(out4) -> scale13/1
  debus/14(out3) -> scale14/1
  debus/15(out2) -> scale15/1
  debus/16(lsb_out1) -> scale16/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..8} (8 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out8) -> addsub1/1
  b_debus/1(msb_out8) -> addsub1/2
  a_debus/2(out7) -> addsub2/1
  b_debus/2(out7) -> addsub2/2
  a_debus/3(out6) -> addsub3/1
  b_debus/3(out6) -> addsub3/2
  a_debus/4(out5) -> addsub4/1
  b_debus/4(out5) -> addsub4/2
  a_debus/5(out4) -> addsub5/1
  b_debus/5(out4) -> addsub5/2
  a_debus/6(out3) -> addsub6/1
  b_debus/6(out3) -> addsub6/2
  a_debus/7(out2) -> addsub7/1
  b_debus/7(out2) -> addsub7/2
  a_debus/8(lsb_out1) -> addsub8/1
  b_debus/8(lsb_out1) -> addsub8/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/mux ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..15} (16 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out16) -> mux0/1
  expand0/1(msb_out16) -> mux0/2
  expand1/1(msb_out16) -> mux0/3
  sel_expand/2(out15) -> mux1/1
  expand0/2(out15) -> mux1/2
  expand1/2(out15) -> mux1/3
  sel_expand/3(out14) -> mux2/1
  expand0/3(out14) -> mux2/2
  expand1/3(out14) -> mux2/3
  sel_expand/4(out13) -> mux3/1
  expand0/4(out13) -> mux3/2
  expand1/4(out13) -> mux3/3
  sel_expand/5(out12) -> mux4/1
  expand0/5(out12) -> mux4/2
  expand1/5(out12) -> mux4/3
  sel_expand/6(out11) -> mux5/1
  expand0/6(out11) -> mux5/2
  expand1/6(out11) -> mux5/3
  sel_expand/7(out10) -> mux6/1
  expand0/7(out10) -> mux6/2
  expand1/7(out10) -> mux6/3
  sel_expand/8(out9) -> mux7/1
  expand0/8(out9) -> mux7/2
  expand1/8(out9) -> mux7/3
  sel_expand/9(out8) -> mux8/1
  expand0/9(out8) -> mux8/2
  expand1/9(out8) -> mux8/3
  sel_expand/10(out7) -> mux9/1
  expand0/10(out7) -> mux9/2
  expand1/10(out7) -> mux9/3
  sel_expand/11(out6) -> mux10/1
  expand0/11(out6) -> mux10/2
  expand1/11(out6) -> mux10/3
  sel_expand/12(out5) -> mux11/1
  expand0/12(out5) -> mux11/2
  expand1/12(out5) -> mux11/3
  sel_expand/13(out4) -> mux12/1
  expand0/13(out4) -> mux12/2
  expand1/13(out4) -> mux12/3
  sel_expand/14(out3) -> mux13/1
  expand0/14(out3) -> mux13/2
  expand1/14(out3) -> mux13/3
  sel_expand/15(out2) -> mux14/1
  expand0/15(out2) -> mux14/2
  expand1/15(out2) -> mux14/3
  sel_expand/16(lsb_out1) -> mux15/1
  expand0/16(lsb_out1) -> mux15/2
  expand1/16(lsb_out1) -> mux15/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  mux4/1 -> d_bussify/5(in5)
  mux5/1 -> d_bussify/6(in6)
  mux6/1 -> d_bussify/7(in7)
  mux7/1 -> d_bussify/8(in8)
  mux8/1 -> d_bussify/9(in9)
  mux9/1 -> d_bussify/10(in10)
  mux10/1 -> d_bussify/11(in11)
  mux11/1 -> d_bussify/12(in12)
  mux12/1 -> d_bussify/13(in13)
  mux13/1 -> d_bussify/14(in14)
  mux14/1 -> d_bussify/15(in15)
  mux15/1 -> d_bussify/16(in16)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/shift_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_{0..15} (16 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1, din0_4/1, din0_5/1, din0_6/1, din0_7/1, din0_8/1, din0_9/1, din0_10/1, din0_11/1, din0_12/1, din0_13/1, din0_14/1, din0_15/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  din0_2/1 -> bussify/3(in3)
  din0_3/1 -> bussify/4(in4)
  din0_4/1 -> bussify/5(in5)
  din0_5/1 -> bussify/6(in6)
  din0_6/1 -> bussify/7(in7)
  din0_7/1 -> bussify/8(in8)
  din0_8/1 -> bussify/9(in9)
  din0_9/1 -> bussify/10(in10)
  din0_10/1 -> bussify/11(in11)
  din0_11/1 -> bussify/12(in12)
  din0_12/1 -> bussify/13(in13)
  din0_13/1 -> bussify/14(in14)
  din0_14/1 -> bussify/15(in15)
  din0_15/1 -> bussify/16(in16)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_1/twiddle ==
  ai : Inport
  bi : Inport  Port=2
  sync_in : Inport  Port=3
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult
  coeff_gen : Subsystem  AncestorBlock=casper_library_ffts_twiddle_coeff_gen/coeff_gen
  ao : Outport
  bwo : Outport  Port=2
  sync_out : Outport  Port=3
  wires:
  bi/1 -> bus_create/1(in1)
  sync_in/1 -> bus_create/2(in2), coeff_gen/1(rst)
  ai/1 -> bus_create/3(in3)
  bus_create/1(bus_out) -> coeff_gen/2(misci)
  coeff_gen/2(misco) -> bus_expand/1(bus_in)
  coeff_gen/1(w) -> bus_mult/1(a)
  bus_expand/2(lsb_out1) -> bus_mult/3(misci)
  bus_expand/1(msb_out2) -> bus_mult/2(b)
  bus_mult/1(a*b) -> bus_convert/1(din)
  bus_mult/2(misco) -> bus_convert/2(misci)
  bus_convert/1(dout) -> bwo/1
  bus_convert/2(misco) -> bus_expand1/1(bus_in)
  bus_expand1/1(msb_out2) -> sync_out/1
  bus_expand1/2(lsb_out1) -> ao/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/addr_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-9  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/addr_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/buf0 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=512  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/buf1 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=512  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/current_map ==
  addra : Inport
  dina : Inport  Port=2
  wea : Inport  Port=3
  addrb : Inport  Port=4
  dinb : Inport  Port=5
  web : Inport  Port=6
  A_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  B_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bram0 : xbsIndex_r4/Dual Port RAM  depth=512  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  init_a=0  init_b=0  rst_a=off  rst_b=off  en_a=off  en_b=off  latency=2  write_mode_A=Read Before Write  write_mode_B=Read Before Write  dbl_ovrd=off  optimize=Speed  block_type=dpram
  ddina : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  ddinb : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addra : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_addrb : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_dina : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_dinb : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_wea : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_web : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  rep_addra : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_addrb : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_wea : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_web : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  A : Outport
  B : Outport  Port=2
  wires:
  addra/1 -> rep_addra/1(in)
  dina/1 -> ddina/1
  wea/1 -> rep_wea/1(in)
  addrb/1 -> rep_addrb/1(in)
  dinb/1 -> ddinb/1
  web/1 -> rep_web/1(in)
  rep_addra/1(out) -> debus_addra/1(bus_in)
  ddina/1 -> debus_dina/1(bus_in)
  rep_wea/1(out) -> debus_wea/1(bus_in)
  rep_addrb/1(out) -> debus_addrb/1(bus_in)
  ddinb/1 -> debus_dinb/1(bus_in)
  rep_web/1(out) -> debus_web/1(bus_in)
  debus_addra/1(msb_lsb_out1) -> bram0/1
  debus_dina/1(msb_lsb_out1) -> bram0/2
  debus_wea/1(msb_lsb_out1) -> bram0/3
  debus_addrb/1(msb_lsb_out1) -> bram0/4
  debus_dinb/1(msb_lsb_out1) -> bram0/5
  debus_web/1(msb_lsb_out1) -> bram0/6
  bram0/1 -> A_bussify/1(in1)
  bram0/2 -> B_bussify/1(in1)
  A_bussify/1(bus_out) -> A/1
  B_bussify/1(bus_out) -> B/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/we_expand ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> msb_out2/1
  slice1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/reorder/we_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/barrel_switcher ==
  sel : Inport
  sync_in : Inport  Port=2
  In1 : Inport  Port=3
  In2 : Inport  Port=4
  Delay_sync : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Mux11 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux21 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_out : Outport
  Out1 : Outport  Port=2
  Out2 : Outport  Port=3
  wires:
  sync_in/1 -> Delay_sync/1
  Delay_sync/1 -> sync_out/1
  sel/1 -> Slice1/1
  Slice1/1 -> Mux11/1, Mux21/1
  In1/1 -> Mux11/2, Mux21/3
  Mux11/1 -> Out1/1
  In2/1 -> Mux21/2, Mux11/3
  Mux21/1 -> Out2/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/db0 ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/df1 ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/dsync ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system roach2_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/munge/join ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  concatenate : xbsIndex_r4/Concat  num_inputs=8  dbl_ovrd=off  block_type=concat
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
