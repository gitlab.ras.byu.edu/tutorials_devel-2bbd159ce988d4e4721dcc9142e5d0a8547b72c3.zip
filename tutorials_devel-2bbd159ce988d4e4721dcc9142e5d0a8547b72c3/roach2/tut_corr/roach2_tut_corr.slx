simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 29 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,fca86624,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,1c72b5be,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_add ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..16} (16 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out16) -> addsub1/1
  b_debus/1(msb_out16) -> addsub1/2
  a_debus/2(out15) -> addsub2/1
  b_debus/2(out15) -> addsub2/2
  a_debus/3(out14) -> addsub3/1
  b_debus/3(out14) -> addsub3/2
  a_debus/4(out13) -> addsub4/1
  b_debus/4(out13) -> addsub4/2
  a_debus/5(out12) -> addsub5/1
  b_debus/5(out12) -> addsub5/2
  a_debus/6(out11) -> addsub6/1
  b_debus/6(out11) -> addsub6/2
  a_debus/7(out10) -> addsub7/1
  b_debus/7(out10) -> addsub7/2
  a_debus/8(out9) -> addsub8/1
  b_debus/8(out9) -> addsub8/2
  a_debus/9(out8) -> addsub9/1
  b_debus/9(out8) -> addsub9/2
  a_debus/10(out7) -> addsub10/1
  b_debus/10(out7) -> addsub10/2
  a_debus/11(out6) -> addsub11/1
  b_debus/11(out6) -> addsub11/2
  a_debus/12(out5) -> addsub12/1
  b_debus/12(out5) -> addsub12/2
  a_debus/13(out4) -> addsub13/1
  b_debus/13(out4) -> addsub13/2
  a_debus/14(out3) -> addsub14/1
  b_debus/14(out3) -> addsub14/2
  a_debus/15(out2) -> addsub15/1
  b_debus/15(out2) -> addsub15/2
  a_debus/16(lsb_out1) -> addsub16/1
  b_debus/16(lsb_out1) -> addsub16/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  addsub9/1 -> op_bussify/9(in9)
  addsub10/1 -> op_bussify/10(in10)
  addsub11/1 -> op_bussify/11(in11)
  addsub12/1 -> op_bussify/12(in12)
  addsub13/1 -> op_bussify/13(in13)
  addsub14/1 -> op_bussify/14(in14)
  addsub15/1 -> op_bussify/15(in15)
  addsub16/1 -> op_bussify/16(in16)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv17 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv18 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv19 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv20 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv21 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv22 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv23 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv24 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv25 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv26 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv27 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv28 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv29 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv30 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv31 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv32 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out32) -> conv1/1(din)
  debus/2(out31) -> conv2/1(din)
  debus/3(out30) -> conv3/1(din)
  debus/4(out29) -> conv4/1(din)
  debus/5(out28) -> conv5/1(din)
  debus/6(out27) -> conv6/1(din)
  debus/7(out26) -> conv7/1(din)
  debus/8(out25) -> conv8/1(din)
  debus/9(out24) -> conv9/1(din)
  debus/10(out23) -> conv10/1(din)
  debus/11(out22) -> conv11/1(din)
  debus/12(out21) -> conv12/1(din)
  debus/13(out20) -> conv13/1(din)
  debus/14(out19) -> conv14/1(din)
  debus/15(out18) -> conv15/1(din)
  debus/16(out17) -> conv16/1(din)
  debus/17(out16) -> conv17/1(din)
  debus/18(out15) -> conv18/1(din)
  debus/19(out14) -> conv19/1(din)
  debus/20(out13) -> conv20/1(din)
  debus/21(out12) -> conv21/1(din)
  debus/22(out11) -> conv22/1(din)
  debus/23(out10) -> conv23/1(din)
  debus/24(out9) -> conv24/1(din)
  debus/25(out8) -> conv25/1(din)
  debus/26(out7) -> conv26/1(din)
  debus/27(out6) -> conv27/1(din)
  debus/28(out5) -> conv28/1(din)
  debus/29(out4) -> conv29/1(din)
  debus/30(out3) -> conv30/1(din)
  debus/31(out2) -> conv31/1(din)
  debus/32(lsb_out1) -> conv32/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv13/1(dout) -> bussify/13(in13)
  conv14/1(dout) -> bussify/14(in14)
  conv15/1(dout) -> bussify/15(in15)
  conv16/1(dout) -> bussify/16(in16)
  conv17/1(dout) -> bussify/17(in17)
  conv18/1(dout) -> bussify/18(in18)
  conv19/1(dout) -> bussify/19(in19)
  conv20/1(dout) -> bussify/20(in20)
  conv21/1(dout) -> bussify/21(in21)
  conv22/1(dout) -> bussify/22(in22)
  conv23/1(dout) -> bussify/23(in23)
  conv24/1(dout) -> bussify/24(in24)
  conv25/1(dout) -> bussify/25(in25)
  conv26/1(dout) -> bussify/26(in26)
  conv27/1(dout) -> bussify/27(in27)
  conv28/1(dout) -> bussify/28(in28)
  conv29/1(dout) -> bussify/29(in29)
  conv30/1(dout) -> bussify/30(in30)
  conv31/1(dout) -> bussify/31(in31)
  conv32/1(dout) -> bussify/32(in32)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  conv13/2(of) -> of_bussify/13(in13)
  conv14/2(of) -> of_bussify/14(in14)
  conv15/2(of) -> of_bussify/15(in15)
  conv16/2(of) -> of_bussify/16(in16)
  conv17/2(of) -> of_bussify/17(in17)
  conv18/2(of) -> of_bussify/18(in18)
  conv19/2(of) -> of_bussify/19(in19)
  conv20/2(of) -> of_bussify/20(in20)
  conv21/2(of) -> of_bussify/21(in21)
  conv22/2(of) -> of_bussify/22(in22)
  conv23/2(of) -> of_bussify/23(in23)
  conv24/2(of) -> of_bussify/24(in24)
  conv25/2(of) -> of_bussify/25(in25)
  conv26/2(of) -> of_bussify/26(in26)
  conv27/2(of) -> of_bussify/27(in27)
  conv28/2(of) -> of_bussify/28(in28)
  conv29/2(of) -> of_bussify/29(in29)
  conv30/2(of) -> of_bussify/30(in30)
  conv31/2(of) -> of_bussify/31(in31)
  conv32/2(of) -> of_bussify/32(in32)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=288  boolean_output=off  mode=Upper Bit Location + Width  bit1=-288  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=288  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv{1..32} (32 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=on  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out32) -> conv1/1
  debus/2(out31) -> conv2/1
  debus/3(out30) -> conv3/1
  debus/4(out29) -> conv4/1
  debus/5(out28) -> conv5/1
  debus/6(out27) -> conv6/1
  debus/7(out26) -> conv7/1
  debus/8(out25) -> conv8/1
  debus/9(out24) -> conv9/1
  debus/10(out23) -> conv10/1
  debus/11(out22) -> conv11/1
  debus/12(out21) -> conv12/1
  debus/13(out20) -> conv13/1
  debus/14(out19) -> conv14/1
  debus/15(out18) -> conv15/1
  debus/16(out17) -> conv16/1
  debus/17(out16) -> conv17/1
  debus/18(out15) -> conv18/1
  debus/19(out14) -> conv19/1
  debus/20(out13) -> conv20/1
  debus/21(out12) -> conv21/1
  debus/22(out11) -> conv22/1
  debus/23(out10) -> conv23/1
  debus/24(out9) -> conv24/1
  debus/25(out8) -> conv25/1
  debus/26(out7) -> conv26/1
  debus/27(out6) -> conv27/1
  debus/28(out5) -> conv28/1
  debus/29(out4) -> conv29/1
  debus/30(out3) -> conv30/1
  debus/31(out2) -> conv31/1
  debus/32(lsb_out1) -> conv32/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  conv13/1 -> bussify/13(in13)
  conv14/1 -> bussify/14(in14)
  conv15/1 -> bussify/15(in15)
  conv16/1 -> bussify/16(in16)
  conv17/1 -> bussify/17(in17)
  conv18/1 -> bussify/18(in18)
  conv19/1 -> bussify/19(in19)
  conv20/1 -> bussify/20(in20)
  conv21/1 -> bussify/21(in21)
  conv22/1 -> bussify/22(in22)
  conv23/1 -> bussify/23(in23)
  conv24/1 -> bussify/24(in24)
  conv25/1 -> bussify/25(in25)
  conv26/1 -> bussify/26(in26)
  conv27/1 -> bussify/27(in27)
  conv28/1 -> bussify/28(in28)
  conv29/1 -> bussify/29(in29)
  conv30/1 -> bussify/30(in30)
  conv31/1 -> bussify/31(in31)
  conv32/1 -> bussify/32(in32)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv17 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv18 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv19 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv20 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv21 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv22 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv23 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv24 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv25 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv26 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv27 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv28 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv29 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv30 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv31 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv32 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out32) -> conv1/1(in)
  debus/2(out31) -> conv2/1(in)
  debus/3(out30) -> conv3/1(in)
  debus/4(out29) -> conv4/1(in)
  debus/5(out28) -> conv5/1(in)
  debus/6(out27) -> conv6/1(in)
  debus/7(out26) -> conv7/1(in)
  debus/8(out25) -> conv8/1(in)
  debus/9(out24) -> conv9/1(in)
  debus/10(out23) -> conv10/1(in)
  debus/11(out22) -> conv11/1(in)
  debus/12(out21) -> conv12/1(in)
  debus/13(out20) -> conv13/1(in)
  debus/14(out19) -> conv14/1(in)
  debus/15(out18) -> conv15/1(in)
  debus/16(out17) -> conv16/1(in)
  debus/17(out16) -> conv17/1(in)
  debus/18(out15) -> conv18/1(in)
  debus/19(out14) -> conv19/1(in)
  debus/20(out13) -> conv20/1(in)
  debus/21(out12) -> conv21/1(in)
  debus/22(out11) -> conv22/1(in)
  debus/23(out10) -> conv23/1(in)
  debus/24(out9) -> conv24/1(in)
  debus/25(out8) -> conv25/1(in)
  debus/26(out7) -> conv26/1(in)
  debus/27(out6) -> conv27/1(in)
  debus/28(out5) -> conv28/1(in)
  debus/29(out4) -> conv29/1(in)
  debus/30(out3) -> conv30/1(in)
  debus/31(out2) -> conv31/1(in)
  debus/32(lsb_out1) -> conv32/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  conv17/1(out) -> bussify/17(in17)
  conv18/1(out) -> bussify/18(in18)
  conv19/1(out) -> bussify/19(in19)
  conv20/1(out) -> bussify/20(in20)
  conv21/1(out) -> bussify/21(in21)
  conv22/1(out) -> bussify/22(in22)
  conv23/1(out) -> bussify/23(in23)
  conv24/1(out) -> bussify/24(in24)
  conv25/1(out) -> bussify/25(in25)
  conv26/1(out) -> bussify/26(in26)
  conv27/1(out) -> bussify/27(in27)
  conv28/1(out) -> bussify/28(in28)
  conv29/1(out) -> bussify/29(in29)
  conv30/1(out) -> bussify/30(in30)
  conv31/1(out) -> bussify/31(in31)
  conv32/1(out) -> bussify/32(in32)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  relational{1..8} (8 alike) : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1, relational4/1, relational5/1, relational6/1, relational7/1, relational8/1
  b_debus/1(msb_out8) -> relational1/2
  b_debus/2(out7) -> relational2/2
  b_debus/3(out6) -> relational3/2
  b_debus/4(out5) -> relational4/2
  b_debus/5(out4) -> relational5/2
  b_debus/6(out3) -> relational6/2
  b_debus/7(out2) -> relational7/2
  b_debus/8(lsb_out1) -> relational8/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  relational4/1 -> bussify/4(in4)
  relational5/1 -> bussify/5(in5)
  relational6/1 -> bussify/6(in6)
  relational7/1 -> bussify/7(in7)
  relational8/1 -> bussify/8(in8)
  bussify/1(bus_out) -> a!=b/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..32} (32 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out32) -> scale1/1
  debus/2(out31) -> scale2/1
  debus/3(out30) -> scale3/1
  debus/4(out29) -> scale4/1
  debus/5(out28) -> scale5/1
  debus/6(out27) -> scale6/1
  debus/7(out26) -> scale7/1
  debus/8(out25) -> scale8/1
  debus/9(out24) -> scale9/1
  debus/10(out23) -> scale10/1
  debus/11(out22) -> scale11/1
  debus/12(out21) -> scale12/1
  debus/13(out20) -> scale13/1
  debus/14(out19) -> scale14/1
  debus/15(out18) -> scale15/1
  debus/16(out17) -> scale16/1
  debus/17(out16) -> scale17/1
  debus/18(out15) -> scale18/1
  debus/19(out14) -> scale19/1
  debus/20(out13) -> scale20/1
  debus/21(out12) -> scale21/1
  debus/22(out11) -> scale22/1
  debus/23(out10) -> scale23/1
  debus/24(out9) -> scale24/1
  debus/25(out8) -> scale25/1
  debus/26(out7) -> scale26/1
  debus/27(out6) -> scale27/1
  debus/28(out5) -> scale28/1
  debus/29(out4) -> scale29/1
  debus/30(out3) -> scale30/1
  debus/31(out2) -> scale31/1
  debus/32(lsb_out1) -> scale32/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  scale17/1 -> bussify/17(in17)
  scale18/1 -> bussify/18(in18)
  scale19/1 -> bussify/19(in19)
  scale20/1 -> bussify/20(in20)
  scale21/1 -> bussify/21(in21)
  scale22/1 -> bussify/22(in22)
  scale23/1 -> bussify/23(in23)
  scale24/1 -> bussify/24(in24)
  scale25/1 -> bussify/25(in25)
  scale26/1 -> bussify/26(in26)
  scale27/1 -> bussify/27(in27)
  scale28/1 -> bussify/28(in28)
  scale29/1 -> bussify/29(in29)
  scale30/1 -> bussify/30(in30)
  scale31/1 -> bussify/31(in31)
  scale32/1 -> bussify/32(in32)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..16} (16 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out16) -> addsub1/1
  b_debus/1(msb_out16) -> addsub1/2
  a_debus/2(out15) -> addsub2/1
  b_debus/2(out15) -> addsub2/2
  a_debus/3(out14) -> addsub3/1
  b_debus/3(out14) -> addsub3/2
  a_debus/4(out13) -> addsub4/1
  b_debus/4(out13) -> addsub4/2
  a_debus/5(out12) -> addsub5/1
  b_debus/5(out12) -> addsub5/2
  a_debus/6(out11) -> addsub6/1
  b_debus/6(out11) -> addsub6/2
  a_debus/7(out10) -> addsub7/1
  b_debus/7(out10) -> addsub7/2
  a_debus/8(out9) -> addsub8/1
  b_debus/8(out9) -> addsub8/2
  a_debus/9(out8) -> addsub9/1
  b_debus/9(out8) -> addsub9/2
  a_debus/10(out7) -> addsub10/1
  b_debus/10(out7) -> addsub10/2
  a_debus/11(out6) -> addsub11/1
  b_debus/11(out6) -> addsub11/2
  a_debus/12(out5) -> addsub12/1
  b_debus/12(out5) -> addsub12/2
  a_debus/13(out4) -> addsub13/1
  b_debus/13(out4) -> addsub13/2
  a_debus/14(out3) -> addsub14/1
  b_debus/14(out3) -> addsub14/2
  a_debus/15(out2) -> addsub15/1
  b_debus/15(out2) -> addsub15/2
  a_debus/16(lsb_out1) -> addsub16/1
  b_debus/16(lsb_out1) -> addsub16/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  addsub9/1 -> op_bussify/9(in9)
  addsub10/1 -> op_bussify/10(in10)
  addsub11/1 -> op_bussify/11(in11)
  addsub12/1 -> op_bussify/12(in12)
  addsub13/1 -> op_bussify/13(in13)
  addsub14/1 -> op_bussify/14(in14)
  addsub15/1 -> op_bussify/15(in15)
  addsub16/1 -> op_bussify/16(in16)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out16) -> join/1(in1)
  split/9(out8) -> join/2(in2)
  split/2(out15) -> join/3(in3)
  split/10(out7) -> join/4(in4)
  split/3(out14) -> join/5(in5)
  split/11(out6) -> join/6(in6)
  split/4(out13) -> join/7(in7)
  split/12(out5) -> join/8(in8)
  split/5(out12) -> join/9(in9)
  split/13(out4) -> join/10(in10)
  split/6(out11) -> join/11(in11)
  split/14(out3) -> join/12(in12)
  split/7(out10) -> join/13(in13)
  split/15(out2) -> join/14(in14)
  split/8(out9) -> join/15(in15)
  split/16(lsb_out1) -> join/16(in16)

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/mux ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..31} (32 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out32) -> mux0/1
  expand0/1(msb_out32) -> mux0/2
  expand1/1(msb_out32) -> mux0/3
  sel_expand/2(out31) -> mux1/1
  expand0/2(out31) -> mux1/2
  expand1/2(out31) -> mux1/3
  sel_expand/3(out30) -> mux2/1
  expand0/3(out30) -> mux2/2
  expand1/3(out30) -> mux2/3
  sel_expand/4(out29) -> mux3/1
  expand0/4(out29) -> mux3/2
  expand1/4(out29) -> mux3/3
  sel_expand/5(out28) -> mux4/1
  expand0/5(out28) -> mux4/2
  expand1/5(out28) -> mux4/3
  sel_expand/6(out27) -> mux5/1
  expand0/6(out27) -> mux5/2
  expand1/6(out27) -> mux5/3
  sel_expand/7(out26) -> mux6/1
  expand0/7(out26) -> mux6/2
  expand1/7(out26) -> mux6/3
  sel_expand/8(out25) -> mux7/1
  expand0/8(out25) -> mux7/2
  expand1/8(out25) -> mux7/3
  sel_expand/9(out24) -> mux8/1
  expand0/9(out24) -> mux8/2
  expand1/9(out24) -> mux8/3
  sel_expand/10(out23) -> mux9/1
  expand0/10(out23) -> mux9/2
  expand1/10(out23) -> mux9/3
  sel_expand/11(out22) -> mux10/1
  expand0/11(out22) -> mux10/2
  expand1/11(out22) -> mux10/3
  sel_expand/12(out21) -> mux11/1
  expand0/12(out21) -> mux11/2
  expand1/12(out21) -> mux11/3
  sel_expand/13(out20) -> mux12/1
  expand0/13(out20) -> mux12/2
  expand1/13(out20) -> mux12/3
  sel_expand/14(out19) -> mux13/1
  expand0/14(out19) -> mux13/2
  expand1/14(out19) -> mux13/3
  sel_expand/15(out18) -> mux14/1
  expand0/15(out18) -> mux14/2
  expand1/15(out18) -> mux14/3
  sel_expand/16(out17) -> mux15/1
  expand0/16(out17) -> mux15/2
  expand1/16(out17) -> mux15/3
  sel_expand/17(out16) -> mux16/1
  expand0/17(out16) -> mux16/2
  expand1/17(out16) -> mux16/3
  sel_expand/18(out15) -> mux17/1
  expand0/18(out15) -> mux17/2
  expand1/18(out15) -> mux17/3
  sel_expand/19(out14) -> mux18/1
  expand0/19(out14) -> mux18/2
  expand1/19(out14) -> mux18/3
  sel_expand/20(out13) -> mux19/1
  expand0/20(out13) -> mux19/2
  expand1/20(out13) -> mux19/3
  sel_expand/21(out12) -> mux20/1
  expand0/21(out12) -> mux20/2
  expand1/21(out12) -> mux20/3
  sel_expand/22(out11) -> mux21/1
  expand0/22(out11) -> mux21/2
  expand1/22(out11) -> mux21/3
  sel_expand/23(out10) -> mux22/1
  expand0/23(out10) -> mux22/2
  expand1/23(out10) -> mux22/3
  sel_expand/24(out9) -> mux23/1
  expand0/24(out9) -> mux23/2
  expand1/24(out9) -> mux23/3
  sel_expand/25(out8) -> mux24/1
  expand0/25(out8) -> mux24/2
  expand1/25(out8) -> mux24/3
  sel_expand/26(out7) -> mux25/1
  expand0/26(out7) -> mux25/2
  expand1/26(out7) -> mux25/3
  sel_expand/27(out6) -> mux26/1
  expand0/27(out6) -> mux26/2
  expand1/27(out6) -> mux26/3
  sel_expand/28(out5) -> mux27/1
  expand0/28(out5) -> mux27/2
  expand1/28(out5) -> mux27/3
  sel_expand/29(out4) -> mux28/1
  expand0/29(out4) -> mux28/2
  expand1/29(out4) -> mux28/3
  sel_expand/30(out3) -> mux29/1
  expand0/30(out3) -> mux29/2
  expand1/30(out3) -> mux29/3
  sel_expand/31(out2) -> mux30/1
  expand0/31(out2) -> mux30/2
  expand1/31(out2) -> mux30/3
  sel_expand/32(lsb_out1) -> mux31/1
  expand0/32(lsb_out1) -> mux31/2
  expand1/32(lsb_out1) -> mux31/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  mux4/1 -> d_bussify/5(in5)
  mux5/1 -> d_bussify/6(in6)
  mux6/1 -> d_bussify/7(in7)
  mux7/1 -> d_bussify/8(in8)
  mux8/1 -> d_bussify/9(in9)
  mux9/1 -> d_bussify/10(in10)
  mux10/1 -> d_bussify/11(in11)
  mux11/1 -> d_bussify/12(in12)
  mux12/1 -> d_bussify/13(in13)
  mux13/1 -> d_bussify/14(in14)
  mux14/1 -> d_bussify/15(in15)
  mux15/1 -> d_bussify/16(in16)
  mux16/1 -> d_bussify/17(in17)
  mux17/1 -> d_bussify/18(in18)
  mux18/1 -> d_bussify/19(in19)
  mux19/1 -> d_bussify/20(in20)
  mux20/1 -> d_bussify/21(in21)
  mux21/1 -> d_bussify/22(in22)
  mux22/1 -> d_bussify/23(in23)
  mux23/1 -> d_bussify/24(in24)
  mux24/1 -> d_bussify/25(in25)
  mux25/1 -> d_bussify/26(in26)
  mux26/1 -> d_bussify/27(in27)
  mux27/1 -> d_bussify/28(in28)
  mux28/1 -> d_bussify/29(in29)
  mux29/1 -> d_bussify/30(in30)
  mux30/1 -> d_bussify/31(in31)
  mux31/1 -> d_bussify/32(in32)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/shift_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_{0..4} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..31} (32 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1, din0_4/1
  din0_0/1 -> din1_0/1, din1_5/1, din1_10/1, din1_15/1, din1_20/1, din1_25/1, din1_30/1
  din0_1/1 -> din1_1/1, din1_6/1, din1_11/1, din1_16/1, din1_21/1, din1_26/1, din1_31/1
  din0_2/1 -> din1_2/1, din1_7/1, din1_12/1, din1_17/1, din1_22/1, din1_27/1
  din0_3/1 -> din1_3/1, din1_8/1, din1_13/1, din1_18/1, din1_23/1, din1_28/1
  din0_4/1 -> din1_4/1, din1_9/1, din1_14/1, din1_19/1, din1_24/1, din1_29/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  din1_4/1 -> bussify/5(in5)
  din1_5/1 -> bussify/6(in6)
  din1_6/1 -> bussify/7(in7)
  din1_7/1 -> bussify/8(in8)
  din1_8/1 -> bussify/9(in9)
  din1_9/1 -> bussify/10(in10)
  din1_10/1 -> bussify/11(in11)
  din1_11/1 -> bussify/12(in12)
  din1_12/1 -> bussify/13(in13)
  din1_13/1 -> bussify/14(in14)
  din1_14/1 -> bussify/15(in15)
  din1_15/1 -> bussify/16(in16)
  din1_16/1 -> bussify/17(in17)
  din1_17/1 -> bussify/18(in18)
  din1_18/1 -> bussify/19(in19)
  din1_19/1 -> bussify/20(in20)
  din1_20/1 -> bussify/21(in21)
  din1_21/1 -> bussify/22(in22)
  din1_22/1 -> bussify/23(in23)
  din1_23/1 -> bussify/24(in24)
  din1_24/1 -> bussify/25(in25)
  din1_25/1 -> bussify/26(in26)
  din1_26/1 -> bussify/27(in27)
  din1_27/1 -> bussify/28(in28)
  din1_28/1 -> bussify/29(in29)
  din1_29/1 -> bussify/30(in30)
  din1_30/1 -> bussify/31(in31)
  din1_31/1 -> bussify/32(in32)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle ==
  ai : Inport
  bi : Inport  Port=2
  sync_in : Inport  Port=3
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult
  coeff_gen : Subsystem  AncestorBlock=casper_library_ffts_twiddle_coeff_gen/coeff_gen
  ao : Outport
  bwo : Outport  Port=2
  sync_out : Outport  Port=3
  wires:
  bi/1 -> bus_create/1(in1)
  sync_in/1 -> bus_create/2(in2), coeff_gen/1(rst)
  ai/1 -> bus_create/3(in3)
  bus_create/1(bus_out) -> coeff_gen/2(misci)
  coeff_gen/2(misco) -> bus_expand/1(bus_in)
  coeff_gen/1(w) -> bus_mult/1(a)
  bus_expand/2(lsb_out1) -> bus_mult/3(misci)
  bus_expand/1(msb_out2) -> bus_mult/2(b)
  bus_mult/1(a*b) -> bus_convert/1(din)
  bus_mult/2(misco) -> bus_convert/2(misci)
  bus_convert/1(dout) -> bwo/1
  bus_convert/2(misco) -> bus_expand1/1(bus_in)
  bus_expand1/1(msb_out2) -> sync_out/1
  bus_expand1/2(lsb_out1) -> ao/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_add ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..8} (8 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out8) -> addsub1/1
  b_debus/1(msb_out8) -> addsub1/2
  a_debus/2(out7) -> addsub2/1
  b_debus/2(out7) -> addsub2/2
  a_debus/3(out6) -> addsub3/1
  b_debus/3(out6) -> addsub3/2
  a_debus/4(out5) -> addsub4/1
  b_debus/4(out5) -> addsub4/2
  a_debus/5(out4) -> addsub5/1
  b_debus/5(out4) -> addsub5/2
  a_debus/6(out3) -> addsub6/1
  b_debus/6(out3) -> addsub6/2
  a_debus/7(out2) -> addsub7/1
  b_debus/7(out2) -> addsub7/2
  a_debus/8(lsb_out1) -> addsub8/1
  b_debus/8(lsb_out1) -> addsub8/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(din)
  debus/2(out15) -> conv2/1(din)
  debus/3(out14) -> conv3/1(din)
  debus/4(out13) -> conv4/1(din)
  debus/5(out12) -> conv5/1(din)
  debus/6(out11) -> conv6/1(din)
  debus/7(out10) -> conv7/1(din)
  debus/8(out9) -> conv8/1(din)
  debus/9(out8) -> conv9/1(din)
  debus/10(out7) -> conv10/1(din)
  debus/11(out6) -> conv11/1(din)
  debus/12(out5) -> conv12/1(din)
  debus/13(out4) -> conv13/1(din)
  debus/14(out3) -> conv14/1(din)
  debus/15(out2) -> conv15/1(din)
  debus/16(lsb_out1) -> conv16/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv13/1(dout) -> bussify/13(in13)
  conv14/1(dout) -> bussify/14(in14)
  conv15/1(dout) -> bussify/15(in15)
  conv16/1(dout) -> bussify/16(in16)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  conv13/2(of) -> of_bussify/13(in13)
  conv14/2(of) -> of_bussify/14(in14)
  conv15/2(of) -> of_bussify/15(in15)
  conv16/2(of) -> of_bussify/16(in16)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1
