simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 4 of 116)

== system roach2_tut_corr/dir_x0/cd ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system roach2_tut_corr/dir_x0/dd ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_32bit : Subsystem
  wires:
  Gateway Out3/1 -> Scope/4
  Gateway Out2/1 -> Scope/3
  Gateway Out1/1 -> Scope/2
  Gateway Out/1 -> Scope/1
  real/1(data_out) -> Terminator/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  new_acc/1 -> Delay3/1
  vacc_32bit/1(dout) -> Reinterpret/1
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> Gateway Out3/1, vacc_32bit/2(new_acc), Counter/1
  vacc_32bit/2(valid) -> Gateway Out2/1, real/3(we), Counter/2
  Counter/1 -> Gateway Out/1, real/1(addr)
  Reinterpret/1 -> Gateway Out1/1, real/2(data_in)

== system roach2_tut_corr/dir_x1/aa ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_32bit : Subsystem
  wires:
  Gateway Out3/1 -> Scope/4
  Gateway Out2/1 -> Scope/3
  Gateway Out1/1 -> Scope/2
  Gateway Out/1 -> Scope/1
  real/1(data_out) -> Terminator/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  new_acc/1 -> Delay3/1
  vacc_32bit/1(dout) -> Reinterpret/1
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> Gateway Out3/1, vacc_32bit/2(new_acc), Counter/1
  vacc_32bit/2(valid) -> Gateway Out2/1, real/3(we), Counter/2
  Counter/1 -> Gateway Out/1, real/1(addr)
  Reinterpret/1 -> Gateway Out1/1, real/2(data_in)

== system roach2_tut_corr/dir_x1/ab ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)

== system roach2_tut_corr/dir_x1/ac ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system roach2_tut_corr/dir_x1/ad ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)

== system roach2_tut_corr/dir_x1/bb ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_32bit : Subsystem
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system roach2_tut_corr/dir_x1/bc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)

== system roach2_tut_corr/dir_x1/bd ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system roach2_tut_corr/dir_x1/cc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_32bit : Subsystem
  wires:
  Gateway Out3/1 -> Scope/4
  Gateway Out2/1 -> Scope/3
  Gateway Out1/1 -> Scope/2
  Gateway Out/1 -> Scope/1
  real/1(data_out) -> Terminator/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  new_acc/1 -> Delay3/1
  vacc_32bit/1(dout) -> Reinterpret/1
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> Gateway Out3/1, vacc_32bit/2(new_acc), Counter/1
  vacc_32bit/2(valid) -> Gateway Out2/1, real/3(we), Counter/2
  Counter/1 -> Gateway Out/1, real/1(addr)
  Reinterpret/1 -> Gateway Out1/1, real/2(data_in)

== system roach2_tut_corr/dir_x1/cd ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_0 : Subsystem
  vacc_1 : Subsystem
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)

== system roach2_tut_corr/dir_x1/dd ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem
  c_to_ri1 : Subsystem
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Shared_BRAM
  vacc_32bit : Subsystem
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system roach2_tut_corr/fft_wideband_real/del_4x_pol0 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol11 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol12 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol13 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol14 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol15 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol3 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol4 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol7 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol8 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_4x_pol9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct13 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct14 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_direct9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/del_sync_4x ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x ==
  sync : Inport
  shift : Inport  Port=2
  pol0_in : Inport  Port=3
  pol1_in : Inport  Port=4
  pol2_in : Inport  Port=5
  pol3_in : Inport  Port=6
  pol4_in : Inport  Port=7
  pol5_in : Inport  Port=8
  pol6_in : Inport  Port=9
  pol7_in : Inport  Port=10
  pol8_in : Inport  Port=11
  pol9_in : Inport  Port=12
  pol10_in : Inport  Port=13
  pol11_in : Inport  Port=14
  pol12_in : Inport  Port=15
  pol13_in : Inport  Port=16
  pol14_in : Inport  Port=17
  pol15_in : Inport  Port=18
  bi_real_unscr_4x : Subsystem  AncestorBlock=casper_library_ffts_internal/bi_real_unscr_4x
  biplex_core : Subsystem  AncestorBlock=casper_library_ffts/biplex_core
  even_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  odd_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  pol0_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  pol1_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  pol2_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  pol3_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  ri_to_c0 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c1 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c2 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c3 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c4 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c5 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c6 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  ri_to_c7 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c
  sync_out : Outport
  pol0_out : Outport  Port=2
  pol1_out : Outport  Port=3
  pol2_out : Outport  Port=4
  pol3_out : Outport  Port=5
  pol4_out : Outport  Port=6
  pol5_out : Outport  Port=7
  pol6_out : Outport  Port=8
  pol7_out : Outport  Port=9
  pol8_out : Outport  Port=10
  pol9_out : Outport  Port=11
  pol10_out : Outport  Port=12
  pol11_out : Outport  Port=13
  pol12_out : Outport  Port=14
  pol13_out : Outport  Port=15
  pol14_out : Outport  Port=16
  pol15_out : Outport  Port=17
  of : Outport  Port=18
  wires:
  pol0_debus/1(msb_out4) -> pol0_out/1
  pol0_in/1 -> ri_to_c0/1(re)
  pol1_in/1 -> ri_to_c0/2(im)
  ri_to_c0/1(c) -> even_bussify/1(in1)
  pol1_debus/1(msb_out4) -> pol1_out/1
  pol2_debus/1(msb_out4) -> pol2_out/1
  pol2_in/1 -> ri_to_c1/1(re)
  pol3_in/1 -> ri_to_c1/2(im)
  ri_to_c1/1(c) -> odd_bussify/1(in1)
  pol3_debus/1(msb_out4) -> pol3_out/1
  pol0_debus/2(out3) -> pol4_out/1
  pol4_in/1 -> ri_to_c2/1(re)
  pol5_in/1 -> ri_to_c2/2(im)
  ri_to_c2/1(c) -> even_bussify/2(in2)
  pol1_debus/2(out3) -> pol5_out/1
  pol2_debus/2(out3) -> pol6_out/1
  pol6_in/1 -> ri_to_c3/1(re)
  pol7_in/1 -> ri_to_c3/2(im)
  ri_to_c3/1(c) -> odd_bussify/2(in2)
  pol3_debus/2(out3) -> pol7_out/1
  pol0_debus/3(out2) -> pol8_out/1
  pol8_in/1 -> ri_to_c4/1(re)
  pol9_in/1 -> ri_to_c4/2(im)
  ri_to_c4/1(c) -> even_bussify/3(in3)
  pol1_debus/3(out2) -> pol9_out/1
  pol2_debus/3(out2) -> pol10_out/1
  pol10_in/1 -> ri_to_c5/1(re)
  pol11_in/1 -> ri_to_c5/2(im)
  ri_to_c5/1(c) -> odd_bussify/3(in3)
  pol3_debus/3(out2) -> pol11_out/1
  pol0_debus/4(lsb_out1) -> pol12_out/1
  pol12_in/1 -> ri_to_c6/1(re)
  pol13_in/1 -> ri_to_c6/2(im)
  ri_to_c6/1(c) -> even_bussify/4(in4)
  pol1_debus/4(lsb_out1) -> pol13_out/1
  pol2_debus/4(lsb_out1) -> pol14_out/1
  pol14_in/1 -> ri_to_c7/1(re)
  pol15_in/1 -> ri_to_c7/2(im)
  ri_to_c7/1(c) -> odd_bussify/4(in4)
  pol3_debus/4(lsb_out1) -> pol15_out/1
  sync/1 -> biplex_core/1(sync)
  shift/1 -> biplex_core/2(shift)
  even_bussify/1(bus_out) -> biplex_core/3(pol1)
  odd_bussify/1(bus_out) -> biplex_core/4(pol2)
  biplex_core/4(of) -> of/1
  biplex_core/1(sync_out) -> bi_real_unscr_4x/1(sync)
  biplex_core/2(out1) -> bi_real_unscr_4x/2(even)
  biplex_core/3(out2) -> bi_real_unscr_4x/3(odd)
  bi_real_unscr_4x/1(sync_out) -> sync_out/1
  bi_real_unscr_4x/2(pol1_out) -> pol0_debus/1(bus_in)
  bi_real_unscr_4x/3(pol2_out) -> pol1_debus/1(bus_in)
  bi_real_unscr_4x/4(pol3_out) -> pol2_debus/1(bus_in)
  bi_real_unscr_4x/5(pol4_out) -> pol3_debus/1(bus_in)

== system roach2_tut_corr/fft_wideband_real/fft_direct ==
  sync : Inport
  shift : Inport  Port=2
  in00 : Inport  Port=3
  in01 : Inport  Port=4
  in02 : Inport  Port=5
  in03 : Inport  Port=6
  in10 : Inport  Port=7
  in11 : Inport  Port=8
  in12 : Inport  Port=9
  in13 : Inport  Port=10
  in20 : Inport  Port=11
  in21 : Inport  Port=12
  in22 : Inport  Port=13
  in23 : Inport  Port=14
  in30 : Inport  Port=15
  in31 : Inport  Port=16
  in32 : Inport  Port=17
  in33 : Inport  Port=18
  abus : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  adebus0_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  adebus1_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  adebus1_1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bbus : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bdebus0_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bdebus1_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bdebus1_1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  butterfly0_0 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  butterfly1_0 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  butterfly1_1 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  combine : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  of_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  of_1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  of_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  of_or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  synct1 : Terminator
  sync_out : Outport
  out00 : Outport  Port=2
  out01 : Outport  Port=3
  out02 : Outport  Port=4
  out03 : Outport  Port=5
  out10 : Outport  Port=6
  out11 : Outport  Port=7
  out12 : Outport  Port=8
  out13 : Outport  Port=9
  out20 : Outport  Port=10
  out21 : Outport  Port=11
  out22 : Outport  Port=12
  out23 : Outport  Port=13
  out30 : Outport  Port=14
  out31 : Outport  Port=15
  out32 : Outport  Port=16
  out33 : Outport  Port=17
  of : Outport  Port=18
  wires:
  in00/1 -> abus/1(in1)
  adebus1_0/1(msb_out4) -> out00/1
  in01/1 -> abus/5(in5)
  adebus1_1/1(msb_out4) -> out01/1
  in02/1 -> bbus/1(in1)
  bdebus1_0/1(msb_out4) -> out02/1
  in03/1 -> bbus/5(in5)
  bdebus1_1/1(msb_out4) -> out03/1
  in10/1 -> abus/2(in2)
  adebus1_0/2(out3) -> out10/1
  in11/1 -> abus/6(in6)
  adebus1_1/2(out3) -> out11/1
  in12/1 -> bbus/2(in2)
  bdebus1_0/2(out3) -> out12/1
  in13/1 -> bbus/6(in6)
  bdebus1_1/2(out3) -> out13/1
  in20/1 -> abus/3(in3)
  adebus1_0/3(out2) -> out20/1
  in21/1 -> abus/7(in7)
  adebus1_1/3(out2) -> out21/1
  in22/1 -> bbus/3(in3)
  bdebus1_0/3(out2) -> out22/1
  in23/1 -> bbus/7(in7)
  bdebus1_1/3(out2) -> out23/1
  in30/1 -> abus/4(in4)
  adebus1_0/4(lsb_out1) -> out30/1
  in31/1 -> abus/8(in8)
  adebus1_1/4(lsb_out1) -> out31/1
  in32/1 -> bbus/4(in4)
  bdebus1_0/4(lsb_out1) -> out32/1
  in33/1 -> bbus/8(in8)
  bdebus1_1/4(lsb_out1) -> out33/1
  of_or/1 -> of_expand/1(bus_in)
  of_expand/1(msb_out2) -> combine/1
  of_expand/2(lsb_out1) -> combine/2
  combine/1 -> of/1
  shift/1 -> slice0/1, slice1/1
  of_0/1 -> of_or/1
  sync/1 -> butterfly0_0/3(sync_in)
  slice0/1 -> butterfly0_0/4(shift)
  abus/1(bus_out) -> butterfly0_0/1(a)
  bbus/1(bus_out) -> butterfly0_0/2(b)
  butterfly0_0/3(of) -> of_0/1
  butterfly0_0/1(a+bw) -> adebus0_0/1(bus_in)
  butterfly0_0/2(a-bw) -> bdebus0_0/1(bus_in)
  of_1/1 -> of_or/2
  butterfly0_0/4(sync_out) -> butterfly1_0/3(sync_in), butterfly1_1/3(sync_in)
  butterfly1_0/4(sync_out) -> sync_out/1
  slice1/1 -> butterfly1_0/4(shift), butterfly1_1/4(shift)
  adebus0_0/1(msb_out2) -> butterfly1_0/1(a)
  adebus0_0/2(lsb_out1) -> butterfly1_0/2(b)
  butterfly1_0/3(of) -> of_1/1
  butterfly1_1/4(sync_out) -> synct1/1
  bdebus0_0/1(msb_out2) -> butterfly1_1/1(a)
  bdebus0_0/2(lsb_out1) -> butterfly1_1/2(b)
  butterfly1_1/3(of) -> of_1/2
  butterfly1_0/1(a+bw) -> adebus1_0/1(bus_in)
  butterfly1_0/2(a-bw) -> bdebus1_0/1(bus_in)
  butterfly1_1/1(a+bw) -> adebus1_1/1(bus_in)
  butterfly1_1/2(a-bw) -> bdebus1_1/1(bus_in)

== system roach2_tut_corr/fft_wideband_real/fft_direct_sync_delay ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/fft_unscrambler ==
  sync : Inport
  in00 : Inport  Port=2
  in01 : Inport  Port=3
  in10 : Inport  Port=4
  in11 : Inport  Port=5
  in20 : Inport  Port=6
  in21 : Inport  Port=7
  in30 : Inport  Port=8
  in31 : Inport  Port=9
  bus0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  en : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  reorder : Subsystem  AncestorBlock=casper_library_reorder/reorder
  square_transposer : Subsystem  AncestorBlock=casper_library_reorder/square_transposer
  ten : Terminator
  sync_out : Outport
  out00 : Outport  Port=2
  out01 : Outport  Port=3
  out10 : Outport  Port=4
  out11 : Outport  Port=5
  out20 : Outport  Port=6
  out21 : Outport  Port=7
  out30 : Outport  Port=8
  out31 : Outport  Port=9
  wires:
  in00/1 -> bus0/1(in1)
  debus0/1(msb_out4) -> out00/1
  in01/1 -> bus1/1(in1)
  debus1/1(msb_out4) -> out01/1
  in10/1 -> bus0/2(in2)
  debus0/2(out3) -> out10/1
  in11/1 -> bus1/2(in2)
  debus1/2(out3) -> out11/1
  in20/1 -> bus0/3(in3)
  debus0/3(out2) -> out20/1
  in21/1 -> bus1/3(in3)
  debus1/3(out2) -> out21/1
  in30/1 -> bus0/4(in4)
  debus0/4(lsb_out1) -> out30/1
  in31/1 -> bus1/4(in4)
  debus1/4(lsb_out1) -> out31/1
  sync/1 -> square_transposer/1(sync)
  square_transposer/1(sync_out) -> reorder/1(sync)
  reorder/1(sync_out) -> sync_out/1
  en/1 -> reorder/2(en)
  reorder/2(valid) -> ten/1
  bus0/1(bus_out) -> square_transposer/2(in0)
  square_transposer/2(out0) -> reorder/3(din0)
  reorder/3(dout0) -> debus0/1(bus_in)
  bus1/1(bus_out) -> square_transposer/3(in1)
  square_transposer/3(out1) -> reorder/4(din1)
  reorder/4(dout1) -> debus1/1(bus_in)

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol0 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol11 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol12 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol13 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol14 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol15 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol3 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol4 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol7 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol8 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_4x_pol9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/fft_wideband_real/in_del_sync_4x ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system roach2_tut_corr/negedge_delay/negedge ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/negedge_delay1/negedge ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/pfb_fir_generic/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(in)
  debus/2(out15) -> conv2/1(in)
  debus/3(out14) -> conv3/1(in)
  debus/4(out13) -> conv4/1(in)
  debus/5(out12) -> conv5/1(in)
  debus/6(out11) -> conv6/1(in)
  debus/7(out10) -> conv7/1(in)
  debus/8(out9) -> conv8/1(in)
  debus/9(out8) -> conv9/1(in)
  debus/10(out7) -> conv10/1(in)
  debus/11(out6) -> conv11/1(in)
  debus/12(out5) -> conv12/1(in)
  debus/13(out4) -> conv13/1(in)
  debus/14(out3) -> conv14/1(in)
  debus/15(out2) -> conv15/1(in)
  debus/16(lsb_out1) -> conv16/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/pfb_fir_generic/bus_create ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  concatenate : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16

== system roach2_tut_corr/pfb_fir_generic/bus_expand ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-270  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-252  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-234  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-198  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-180  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-162  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1
