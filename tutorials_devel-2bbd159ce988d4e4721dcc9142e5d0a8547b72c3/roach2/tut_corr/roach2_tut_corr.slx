simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 34 of 116)

== system roach2_tut_corr/quant1/coeffs/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/quant2/coeffs/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/quant2/coeffs/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/quant2/coeffs/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/quant3/coeffs/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/quant3/coeffs/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/quant3/coeffs/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc0/bram/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/snap_adc0/bram/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc0/bram/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc1/bram/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/snap_adc1/bram/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc1/bram/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc2/bram/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/snap_adc2/bram/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc2/bram/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc3/bram/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/snap_adc3/bram/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snap_adc3/bram/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/snapshot_eq/ss/add_gen/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=XNOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system roach2_tut_corr/snapshot_eq/ss/basic_ctrl/dram_munge ==
  note: 1st output same time as last input
  note: Choose DRAM data or standard. Constant input to muxes should ensure other path optimised away
  note: Buffer 4 input words when using DRAM then combine and output the first two, then second. Ensures that a full burst goes through every time so that status register records number of bytes fully in DRAM
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  init : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical2 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Register{,1..3,5} (5 alike) : xbsIndex_r4/Register  init=0  rst=off  en=on  dbl_ovrd=off  block_type=register
  Register4 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Relational{,1..3} (4 alike) : xbsIndex_r4/Relational  mode=a=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  con0 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=2  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  con1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=2  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  con2 : xbsIndex_r4/Constant  const=2  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=2  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  con3 : xbsIndex_r4/Constant  const=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=2  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  data_choice : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=64  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  dout_count : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=1  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  block_type=counter
  dram : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  input_count : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=2  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  block_type=counter
  vout_choice : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  we_choice : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  vout : Outport
  dout : Outport  Port=2
  we_o : Outport  Port=3
  wires:
  Register3/1 -> Concat1/4
  Register2/1 -> Concat1/2
  Constant/1 -> Concat1/3, Concat1/1, Concat/3, Concat/1
  Register1/1 -> Concat/4
  Register/1 -> Concat/2
  [vin] -> vout_choice/2
  Register5/1 -> vout_choice/3
  vout_choice/1 -> vout/1
  Logical2/1 -> Register5/2
  [we] -> Logical2/2, Register4/2
  vin/1 -> [vin], Register5/1
  Register4/1 -> Logical2/1
  [init] -> Register4/3, Register4/1
  dram/1 -> vout_choice/1, we_choice/1, data_choice/1
  [din] -> data_choice/2
  Mux1/1 -> data_choice/3
  [we] -> we_choice/2
  Delay1/1 -> we_choice/3
  we_choice/1 -> we_o/1
  dout_count/1 -> Mux1/1
  [init] -> dout_count/1
  Logical1/1 -> Delay1/1, dout_count/2
  Concat1/1 -> Mux1/3
  Concat/1 -> Mux1/2
  Delay/1 -> Logical1/2
  Logical/1 -> Logical1/1, Delay/1
  Relational3/1 -> Logical/1, Register3/2
  Relational2/1 -> Register2/2
  Relational1/1 -> Register1/2
  Relational/1 -> Register/2
  con3/1 -> Relational3/2
  con2/1 -> Relational2/2
  con1/1 -> Relational1/2
  con0/1 -> Relational/2
  input_count/1 -> Relational3/1, Relational2/1, Relational1/1, Relational/1
  din/1 -> [din], Register3/1, Register2/1, Register1/1, Register/1
  we/1 -> [we], Logical/2, input_count/2
  init/1 -> [init], input_count/1
  data_choice/1 -> dout/1

== system roach2_tut_corr/snapshot_eq/ss/bram/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/snapshot_eq/ss/bram/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=64  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/snapshot_eq/ss/bram/munge_in ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/2(lsb_out1) -> join/1(in1)
  split/1(msb_out2) -> join/2(in2)

== system roach2_tut_corr/snapshot_eq/ss/bram/munge_out ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/2(lsb_out1) -> join/1(in1)
  split/1(msb_out2) -> join/2(in2)

== system roach2_tut_corr/dir_x0/aa/real/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/aa/real/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/aa/real/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/aa/vacc_32bit/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Delay/1 -> Inverter/1
  Inverter/1 -> Logical/1
  In/1 -> Delay/1, Logical/2
  Logical/1 -> Out/1

== system roach2_tut_corr/dir_x0/ab/imag/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/ab/imag/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ab/imag/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ab/real/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/ab/real/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ab/real/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ab/vacc_0/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Logical/1 -> Out/1
  In/1 -> Logical/2, Delay/1
  Inverter/1 -> Logical/1
  Delay/1 -> Inverter/1

== system roach2_tut_corr/dir_x0/ab/vacc_1/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Delay/1 -> Inverter/1
  Inverter/1 -> Logical/1
  In/1 -> Delay/1, Logical/2
  Logical/1 -> Out/1

== system roach2_tut_corr/dir_x0/ac/imag/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/ac/imag/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ac/imag/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/ac/real/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1
