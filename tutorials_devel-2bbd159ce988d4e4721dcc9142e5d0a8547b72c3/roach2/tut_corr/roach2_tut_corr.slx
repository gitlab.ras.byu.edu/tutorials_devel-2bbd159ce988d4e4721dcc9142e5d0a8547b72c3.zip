simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 37 of 116)

== system roach2_tut_corr/dir_x1/cd/real/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/cd/real/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/real/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/vacc_0/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Delay/1 -> Inverter/1
  Inverter/1 -> Logical/1
  In/1 -> Delay/1, Logical/2
  Logical/1 -> Out/1

== system roach2_tut_corr/dir_x1/cd/vacc_1/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Logical/1 -> Out/1
  In/1 -> Logical/2, Delay/1
  Inverter/1 -> Logical/1
  Delay/1 -> Inverter/1

== system roach2_tut_corr/dir_x1/dd/real/mem/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/dd/real/mem/sim_munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/dd/real/mem/sim_munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/dd/vacc_32bit/pulse_ext/posedge ==
  In : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Out : Outport
  wires:
  Delay/1 -> Inverter/1
  Inverter/1 -> Logical/1
  In/1 -> Delay/1, Logical/2
  Logical/1 -> Out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_even_real ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_odd_real ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(in)
  debus/2(out15) -> conv2/1(in)
  debus/3(out14) -> conv3/1(in)
  debus/4(out13) -> conv4/1(in)
  debus/5(out12) -> conv5/1(in)
  debus/6(out11) -> conv6/1(in)
  debus/7(out10) -> conv7/1(in)
  debus/8(out9) -> conv8/1(in)
  debus/9(out8) -> conv9/1(in)
  debus/10(out7) -> conv10/1(in)
  debus/11(out6) -> conv11/1(in)
  debus/12(out5) -> conv12/1(in)
  debus/13(out4) -> conv13/1(in)
  debus/14(out3) -> conv14/1(in)
  debus/15(out2) -> conv15/1(in)
  debus/16(lsb_out1) -> conv16/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_expand_a ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_expand_b ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..16} (16 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> scale1/1
  debus/2(out15) -> scale2/1
  debus/3(out14) -> scale3/1
  debus/4(out13) -> scale4/1
  debus/5(out12) -> scale5/1
  debus/6(out11) -> scale6/1
  debus/7(out10) -> scale7/1
  debus/8(out9) -> scale8/1
  debus/9(out8) -> scale9/1
  debus/10(out7) -> scale10/1
  debus/11(out6) -> scale11/1
  debus/12(out5) -> scale12/1
  debus/13(out4) -> scale13/1
  debus/14(out3) -> scale14/1
  debus/15(out2) -> scale15/1
  debus/16(lsb_out1) -> scale16/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_a ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/3(out6) -> join/2(in2)
  split/5(out4) -> join/3(in3)
  split/7(out2) -> join/4(in4)
  split/2(out7) -> join/5(in5)
  split/4(out5) -> join/6(in6)
  split/6(out3) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_b ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/3(out6) -> join/2(in2)
  split/5(out4) -> join/3(in3)
  split/7(out2) -> join/4(in4)
  split/2(out7) -> join/5(in5)
  split/4(out5) -> join/6(in6)
  split/6(out3) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_even ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_odd ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/sub_even_imag ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/sub_odd_imag ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/add_even_real ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/add_odd_real ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> conv1/1(in)
  debus/2(out15) -> conv2/1(in)
  debus/3(out14) -> conv3/1(in)
  debus/4(out13) -> conv4/1(in)
  debus/5(out12) -> conv5/1(in)
  debus/6(out11) -> conv6/1(in)
  debus/7(out10) -> conv7/1(in)
  debus/8(out9) -> conv8/1(in)
  debus/9(out8) -> conv9/1(in)
  debus/10(out7) -> conv10/1(in)
  debus/11(out6) -> conv11/1(in)
  debus/12(out5) -> conv12/1(in)
  debus/13(out4) -> conv13/1(in)
  debus/14(out3) -> conv14/1(in)
  debus/15(out2) -> conv15/1(in)
  debus/16(lsb_out1) -> conv16/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/bus_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/bus_expand_a ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/bus_expand_b ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=72  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  scale{1..16} (16 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out16) -> scale1/1
  debus/2(out15) -> scale2/1
  debus/3(out14) -> scale3/1
  debus/4(out13) -> scale4/1
  debus/5(out12) -> scale5/1
  debus/6(out11) -> scale6/1
  debus/7(out10) -> scale7/1
  debus/8(out9) -> scale8/1
  debus/9(out8) -> scale9/1
  debus/10(out7) -> scale10/1
  debus/11(out6) -> scale11/1
  debus/12(out5) -> scale12/1
  debus/13(out4) -> scale13/1
  debus/14(out3) -> scale14/1
  debus/15(out2) -> scale15/1
  debus/16(lsb_out1) -> scale16/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/munge_a ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/3(out6) -> join/2(in2)
  split/5(out4) -> join/3(in3)
  split/7(out2) -> join/4(in4)
  split/2(out7) -> join/5(in5)
  split/4(out5) -> join/6(in6)
  split/6(out3) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/munge_b ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/3(out6) -> join/2(in2)
  split/5(out4) -> join/3(in3)
  split/7(out2) -> join/4(in4)
  split/2(out7) -> join/5(in5)
  split/4(out5) -> join/6(in6)
  split/6(out3) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/munge_even ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/munge_odd ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out8) -> join/1(in1)
  split/5(out4) -> join/2(in2)
  split/2(out7) -> join/3(in3)
  split/6(out3) -> join/4(in4)
  split/3(out6) -> join/5(in5)
  split/7(out2) -> join/6(in6)
  split/4(out5) -> join/7(in7)
  split/8(lsb_out1) -> join/8(in8)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/sub_even_imag ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1/sub_odd_imag ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addsub{1..4} (4 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=19  bin_pt=17  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out4) -> addsub1/1
  b_debus/1(msb_out4) -> addsub1/2
  a_debus/2(out3) -> addsub2/1
  b_debus/2(out3) -> addsub2/2
  a_debus/3(out2) -> addsub3/1
  b_debus/3(out2) -> addsub3/2
  a_debus/4(lsb_out1) -> addsub4/1
  b_debus/4(lsb_out1) -> addsub4/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  op_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj0 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj1 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj2 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj3 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux0 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out4) -> mux0/1
  expand0/1(msb_out4) -> mux0/2
  expand1/1(msb_out4) -> mux0/3
  sel_expand/2(out3) -> mux1/1
  expand0/2(out3) -> mux1/2
  expand1/2(out3) -> mux1/3
  sel_expand/3(out2) -> mux2/1
  expand0/3(out2) -> mux2/2
  expand1/3(out2) -> mux2/3
  sel_expand/4(lsb_out1) -> mux3/1
  expand0/4(lsb_out1) -> mux3/2
  expand1/4(lsb_out1) -> mux3/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux1 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out4) -> mux0/1
  expand0/1(msb_out4) -> mux0/2
  expand1/1(msb_out4) -> mux0/3
  sel_expand/2(out3) -> mux1/1
  expand0/2(out3) -> mux1/2
  expand1/2(out3) -> mux1/3
  sel_expand/3(out2) -> mux2/1
  expand0/3(out2) -> mux2/2
  expand1/3(out2) -> mux2/3
  sel_expand/4(lsb_out1) -> mux3/1
  expand0/4(lsb_out1) -> mux3/2
  expand1/4(lsb_out1) -> mux3/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux2 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out4) -> mux0/1
  expand0/1(msb_out4) -> mux0/2
  expand1/1(msb_out4) -> mux0/3
  sel_expand/2(out3) -> mux1/1
  expand0/2(out3) -> mux1/2
  expand1/2(out3) -> mux1/3
  sel_expand/3(out2) -> mux2/1
  expand0/3(out2) -> mux2/2
  expand1/3(out2) -> mux2/3
  sel_expand/4(lsb_out1) -> mux3/1
  expand0/4(lsb_out1) -> mux3/2
  expand1/4(lsb_out1) -> mux3/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  d_bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux3 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out4) -> mux0/1
  expand0/1(msb_out4) -> mux0/2
  expand1/1(msb_out4) -> mux0/3
  sel_expand/2(out3) -> mux1/1
  expand0/2(out3) -> mux1/2
  expand1/2(out3) -> mux1/3
  sel_expand/3(out2) -> mux2/1
  expand0/3(out2) -> mux2/2
  expand1/3(out2) -> mux2/3
  sel_expand/4(lsb_out1) -> mux3/1
  expand0/4(lsb_out1) -> mux3/2
  expand1/4(lsb_out1) -> mux3/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  d_bussify/1(bus_out) -> out/1
