simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 24 of 116)

== system roach2_tut_corr/dir_x0/bc/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/bc/imag/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/bc/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bc/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bc/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/bc/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/bc/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bc/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bc/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system roach2_tut_corr/dir_x0/bc/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system roach2_tut_corr/dir_x0/bc/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x0/bc/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/dir_x0/bd/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/bd/imag/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/bd/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bd/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bd/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/bd/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/bd/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bd/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/bd/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x0/bd/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/dir_x0/bd/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system roach2_tut_corr/dir_x0/bd/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system roach2_tut_corr/dir_x0/cc/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/cc/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/cc/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/cc/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/cc/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x0/cc/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/dir_x0/cd/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/cd/imag/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/cd/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/cd/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x0/cd/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x0/cd/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x0/cd/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1
