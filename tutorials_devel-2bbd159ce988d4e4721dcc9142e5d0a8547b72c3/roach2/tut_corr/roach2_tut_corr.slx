simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 38 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate1 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate2 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate3 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/addr_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_lsb_out1 : Outport
  wires:
  bus_in/1 -> slice1/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> msb_lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/addr_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  out : Outport
  wires:
  in/1 -> bussify/1(in1)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/buf0 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/we_expand ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_lsb_out1 : Outport
  wires:
  bus_in/1 -> slice1/1
  slice1/1 -> msb_lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/we_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  out : Outport
  wires:
  in/1 -> bussify/1(in1)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd/addr_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_lsb_out1 : Outport
  wires:
  bus_in/1 -> slice1/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> msb_lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd/addr_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  out : Outport
  wires:
  in/1 -> bussify/1(in1)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd/buf0 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd/we_expand ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_lsb_out1 : Outport
  wires:
  bus_in/1 -> slice1/1
  slice1/1 -> msb_lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd/we_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  out : Outport
  wires:
  in/1 -> bussify/1(in1)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/addr_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=-24  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=-16  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=-8  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/addr_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/buf0 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/buf1 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/buf2 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/buf3 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_out4) -> bram0/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_out4) -> bram0/3
  debus_addr/2(out3) -> bram1/1
  debus_din/2(out3) -> bram1/2
  debus_we/2(out3) -> bram1/3
  debus_addr/3(out2) -> bram2/1
  debus_din/3(out2) -> bram2/2
  debus_we/3(out2) -> bram2/3
  debus_addr/4(lsb_out1) -> bram3/1
  debus_din/4(lsb_out1) -> bram3/2
  debus_we/4(lsb_out1) -> bram3/3
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/we_expand ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-3  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> msb_out4/1
  slice3/1 -> out3/1
  slice2/1 -> out2/1
  slice1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out/we_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  din1_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> din1_0/1, din1_2/1
  din0_1/1 -> din1_1/1, din1_3/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_pass_through
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay0 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_lsb_out1) -> bram0/1, bram1/1, bram2/1, bram3/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_lsb_out1) -> bram0/3, bram1/3, bram2/3, bram3/3
  debus_din/2(out3) -> bram1/2
  debus_din/3(out2) -> bram2/2
  debus_din/4(lsb_out1) -> bram3/2
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1/delay1 ==
  addr : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  bram{0..3} (4 alike) : xbsIndex_r4/Single Port RAM  depth=256  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=3  dbl_ovrd=off  optimize=Speed  block_type=spram
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  debus_addr : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_din : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  debus_we : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  din_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  rep_addr : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  rep_we : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  dout : Outport
  wires:
  addr/1 -> rep_addr/1(in)
  din/1 -> ddin/1
  we/1 -> rep_we/1(in)
  rep_addr/1(out) -> debus_addr/1(bus_in)
  ddin/1 -> debus_din/1(bus_in)
  rep_we/1(out) -> debus_we/1(bus_in)
  debus_addr/1(msb_lsb_out1) -> bram0/1, bram1/1, bram2/1, bram3/1
  debus_din/1(msb_out4) -> bram0/2
  debus_we/1(msb_lsb_out1) -> bram0/3, bram1/3, bram2/3, bram3/3
  debus_din/2(out3) -> bram1/2
  debus_din/3(out2) -> bram2/2
  debus_din/4(lsb_out1) -> bram3/2
  bram0/1 -> din_bussify/1(in1)
  bram1/1 -> din_bussify/2(in2)
  bram2/1 -> din_bussify/3(in3)
  bram3/1 -> din_bussify/4(in4)
  din_bussify/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_stage_2
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=128  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=128  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_3/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_3/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=64  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_3/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=64  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_4/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_4/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=32  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_4/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=32  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_5/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_5/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=16  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_5/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=16  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_6/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1
