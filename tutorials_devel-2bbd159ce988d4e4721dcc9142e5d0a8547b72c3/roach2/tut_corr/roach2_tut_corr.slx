simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 28 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  dbl_ovrd=off  optimize=Speed  use_rpm=on  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_lsb_out1) -> buf0/3(we)
  addr_expand/1(msb_lsb_out1) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  dbl_ovrd=off  optimize=Speed  use_rpm=on  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_lsb_out1) -> buf0/3(we)
  addr_expand/1(msb_lsb_out1) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  din1 : Inport  Port=4
  din2 : Inport  Port=5
  din3 : Inport  Port=6
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  buf1 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  buf2 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  buf3 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_din{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  dbl_ovrd=off  reg_retiming=on  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  dbl_ovrd=off  optimize=Speed  use_rpm=on  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  dbl_ovrd=off  reg_retiming=on  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  dout1 : Outport  Port=4
  dout2 : Outport  Port=5
  dout3 : Outport  Port=6
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  din1/1 -> delay_din1/1
  din2/1 -> delay_din2/1
  din3/1 -> delay_din3/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_out4) -> buf0/3(we)
  addr_expand/1(msb_out4) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  we_expand/2(out3) -> buf1/3(we)
  addr_expand/2(out3) -> buf1/1(addr)
  delay_din1/1 -> buf1/2(din)
  buf1/1(dout) -> dout1/1
  we_expand/3(out2) -> buf2/3(we)
  addr_expand/3(out2) -> buf2/1(addr)
  delay_din2/1 -> buf2/2(din)
  buf2/1(dout) -> dout2/1
  we_expand/4(lsb_out1) -> buf3/3(we)
  addr_expand/4(lsb_out1) -> buf3/1(addr)
  delay_din3/1 -> buf3/2(din)
  buf3/1(dout) -> dout3/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/sync_delay ==
  In : Inport
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=DelayLen  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=UseCounter  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Down  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=on  rst=off  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  use_rpm=on  block_type=counter
  Logical : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Relational : xbsIndex_r4/Relational  mode=a=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  warn period Logical0 : xbsReplacements_r4/Warning  period=1
  warn period Relational10 : xbsReplacements_r4/Warning  period=1
  Out : Outport
  wires:
  Mux/1 -> Out/1
  Constant3/1 -> Mux/1
  Relational/1 -> Mux/3
  Relational1/1 -> Logical/2
  Logical/1 -> Counter/3
  In/1 -> Mux/2, Logical/1, Counter/1
  Constant2/1 -> Counter/2
  Constant/1 -> Relational/1
  Constant1/1 -> Relational1/2
  Counter/1 -> Relational/2, Relational1/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  addr0 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  addr1 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=7  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  we0 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  we1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  dsync0/1 -> dsync2/1
  dsync2/1 -> dsync1/1, counter/1
  din0/1 -> din1/1
  din1/1 -> mux1/2, mux0/3
  addr0/1 -> delay0/1(addr)
  we0/1 -> delay0/3(we)
  addr1/1 -> delay1/1(addr)
  we1/1 -> delay1/3(we)
  in2/1 -> delay0/2(din)
  mux1/1 -> delay1/2(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,1270bb14,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_3 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,04961a6a,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_4 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,b5591290,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_5 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,eafdfd08,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_6 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,7a8c02d8,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1
