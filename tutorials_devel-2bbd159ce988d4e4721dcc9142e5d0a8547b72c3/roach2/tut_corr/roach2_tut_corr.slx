simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 27 of 116)

== system roach2_tut_corr/dir_x1/bd/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x1/bd/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/bd/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/bd/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system roach2_tut_corr/dir_x1/bd/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system roach2_tut_corr/dir_x1/bd/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x1/bd/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/dir_x1/cc/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/cc/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x1/cc/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cc/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cc/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system roach2_tut_corr/dir_x1/cc/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system roach2_tut_corr/dir_x1/cd/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/cd/imag/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x1/cd/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/cd/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x1/cd/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/cd/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x1/cd/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/dir_x1/cd/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system roach2_tut_corr/dir_x1/cd/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system roach2_tut_corr/dir_x1/dd/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  dbl_ovrd=off  pipeline=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system roach2_tut_corr/dir_x1/dd/real/mem ==
  note: Undo data manipulation on way in and redo on way out for simulated data
  note: Undo address manipulation for simulated data
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  Disregard Subsystem : xbsIndex_r4/Disregard Subsystem  Tag=discardX  block_type=disregard
  calc_add : Subsystem
  ram : xbsIndex_r4/Single Port RAM  depth=2^addr_width  initVector=init_vals  distributed_mem=Block RAM  write_mode=Read After Write  rst=off  init_reg=0  en=off  latency=1  dbl_ovrd=off  optimize=Area  block_type=spram
  sim_addr : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_in : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  sim_data_out : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  UseAsDAC=off  DACChannel='1'  block_type=gatewayout
  sim_munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge
  sim_we : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  quantization=Truncate  overflow=Wrap  period=sample_rate  dbl_ovrd=off  timing_constraint=None  locs_specified=off  LOCs={}  UseAsADC=off  ADCChannel='1'  inherit_from_input=off  hdl_port=on  block_type=gatewayin
  Out1 : Outport
  wires:
  calc_add/1(out) -> ram/1
  sim_munge_out/1(dout) -> sim_data_out/1
  In1/1 -> sim_addr/1
  In2/1 -> sim_data_in/1
  sim_data_out/1 -> Out1/1
  In3/1 -> sim_we/1
  sim_addr/1 -> calc_add/1(in)
  sim_data_in/1 -> sim_munge_in/1(din)
  sim_we/1 -> ram/3
  ram/1 -> sim_munge_out/1(din)
  sim_munge_in/1(dout) -> ram/2

== system roach2_tut_corr/dir_x1/dd/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/dd/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret_out/1

== system roach2_tut_corr/dir_x1/dd/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system roach2_tut_corr/dir_x1/dd/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/delay0 ==
  din : Inport
  constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  use_rpm=off  block_type=counter
  ram : xbsIndex_r4/Single Port RAM  depth=256  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  dout : Outport
  wires:
  counter/1 -> ram/1
  din/1 -> ram/2
  constant/1 -> ram/3
  ram/1 -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/delay1 ==
  din : Inport
  constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  use_rpm=off  block_type=counter
  ram : xbsIndex_r4/Single Port RAM  depth=256  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  dbl_ovrd=off  optimize=Area  block_type=spram
  dout : Outport
  wires:
  counter/1 -> ram/1
  din/1 -> ram/2
  constant/1 -> ram/3
  ram/1 -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0 ==
  a : Inport
  b : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  add_even_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  add_odd_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand_a : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand_b : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  munge_a : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_b : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_even : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_odd : Subsystem  AncestorBlock=casper_library_flow_control/munge
  ri_to_c : casper_library_misc/ri_to_c
  ri_to_c1 : casper_library_misc/ri_to_c
  sub_even_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  sub_odd_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  even : Outport
  odd : Outport  Port=2
  wires:
  b/1 -> munge_b/1(din)
  a/1 -> munge_a/1(din)
  munge_a/1(dout) -> bus_expand_a/1(bus_in)
  munge_b/1(dout) -> bus_expand_b/1(bus_in)
  bus_expand_a/1(msb_out2) -> add_even_real/1(a), sub_odd_imag/2(b)
  bus_expand_b/1(msb_out2) -> add_even_real/2(b), sub_odd_imag/1(a)
  bus_expand_a/2(lsb_out1) -> sub_even_imag/1(a), add_odd_real/1(a)
  bus_expand_b/2(lsb_out1) -> sub_even_imag/2(b), add_odd_real/2(b)
  add_even_real/1(dout) -> Concat/1
  sub_odd_imag/1(dout) -> Concat/2
  sub_even_imag/1(dout) -> Concat/3
  add_odd_real/1(dout) -> Concat/4
  Concat/1 -> bus_scale/1(din)
  bus_scale/1(dout) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/3(out2) -> ri_to_c/2
  bus_expand/1(msb_out4) -> ri_to_c/1
  bus_expand/2(out3) -> ri_to_c1/2
  bus_expand/4(lsb_out1) -> ri_to_c1/1
  ri_to_c/1 -> munge_even/1(din)
  ri_to_c1/1 -> munge_odd/1(din)
  munge_even/1(dout) -> even/1
  munge_odd/1(dout) -> odd/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1 ==
  a : Inport
  b : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  add_even_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  add_odd_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand_a : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_expand_b : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  munge_a : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_b : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_even : Subsystem  AncestorBlock=casper_library_flow_control/munge
  munge_odd : Subsystem  AncestorBlock=casper_library_flow_control/munge
  ri_to_c : casper_library_misc/ri_to_c
  ri_to_c1 : casper_library_misc/ri_to_c
  sub_even_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  sub_odd_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  even : Outport
  odd : Outport  Port=2
  wires:
  b/1 -> munge_b/1(din)
  a/1 -> munge_a/1(din)
  munge_a/1(dout) -> bus_expand_a/1(bus_in)
  munge_b/1(dout) -> bus_expand_b/1(bus_in)
  bus_expand_a/1(msb_out2) -> add_even_real/1(a), sub_odd_imag/2(b)
  bus_expand_b/1(msb_out2) -> add_even_real/2(b), sub_odd_imag/1(a)
  bus_expand_a/2(lsb_out1) -> sub_even_imag/1(a), add_odd_real/1(a)
  bus_expand_b/2(lsb_out1) -> sub_even_imag/2(b), add_odd_real/2(b)
  add_even_real/1(dout) -> Concat/1
  sub_odd_imag/1(dout) -> Concat/2
  sub_even_imag/1(dout) -> Concat/3
  add_odd_real/1(dout) -> Concat/4
  Concat/1 -> bus_scale/1(din)
  bus_scale/1(dout) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/3(out2) -> ri_to_c/2
  bus_expand/1(msb_out4) -> ri_to_c/1
  bus_expand/2(out3) -> ri_to_c1/2
  bus_expand/4(lsb_out1) -> ri_to_c1/1
  ri_to_c/1 -> munge_even/1(din)
  ri_to_c1/1 -> munge_odd/1(din)
  munge_even/1(dout) -> even/1
  munge_odd/1(dout) -> odd/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum ==
  sync : Inport
  din0 : Inport  Port=2
  reo_in0 : Inport  Port=3
  din1 : Inport  Port=4
  reo_in1 : Inport  Port=5
  din2 : Inport  Port=6
  reo_in2 : Inport  Port=7
  din3 : Inport  Port=8
  reo_in3 : Inport  Port=9
  complex_conj0 : Subsystem  AncestorBlock=casper_library_misc/complex_conj
  complex_conj1 : Subsystem  AncestorBlock=casper_library_misc/complex_conj
  complex_conj2 : Subsystem  AncestorBlock=casper_library_misc/complex_conj
  complex_conj3 : Subsystem  AncestorBlock=casper_library_misc/complex_conj
  constant : xbsIndex_r4/Constant  const=256  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=9  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  dbl_ovrd=off  use_behavioral_HDL=on  implementation=Fabric  block_type=counter
  delay{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + bram_latency + negate_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  dmux0 : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  dmux1 : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  dmux2 : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  dmux3 : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  relational : xbsIndex_r4/Relational  mode=a>b  en=off  latency=0  dbl_ovrd=off  block_type=relational
  sel_replicate0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sel_replicate1 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sel_replicate2 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sel_replicate3 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  sync_delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + bram_latency + negate_latency - ceil(log2(n_inputs))  dbl_ovrd=off  reg_retiming=on  block_type=delay
  sync_delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + ceil(log2(n_inputs))  dbl_ovrd=off  reg_retiming=on  block_type=delay
  sync_out : Outport
  dout0 : Outport  Port=2
  dout1 : Outport  Port=3
  dout2 : Outport  Port=4
  dout3 : Outport  Port=5
  wires:
  sync/1 -> sync_delay0/1
  sync_delay0/1 -> counter/1, sync_delay1/1
  counter/1 -> relational/1
  constant/1 -> relational/2
  sync_delay1/1 -> sync_out/1
  din0/1 -> delay0/1
  reo_in0/1 -> complex_conj0/1(z)
  relational/1 -> sel_replicate0/1(in), sel_replicate1/1(in), sel_replicate2/1(in), sel_replicate3/1(in)
  sel_replicate0/1(out) -> dmux0/1(sel)
  delay0/1 -> dmux0/2(d0)
  complex_conj0/1(z*) -> dmux0/3(d1)
  dmux0/1(out) -> dout0/1
  din1/1 -> delay1/1
  reo_in1/1 -> complex_conj1/1(z)
  sel_replicate1/1(out) -> dmux1/1(sel)
  delay1/1 -> dmux1/2(d0)
  complex_conj1/1(z*) -> dmux1/3(d1)
  dmux1/1(out) -> dout1/1
  din2/1 -> delay2/1
  reo_in2/1 -> complex_conj2/1(z)
  sel_replicate2/1(out) -> dmux2/1(sel)
  delay2/1 -> dmux2/2(d0)
  complex_conj2/1(z*) -> dmux2/3(d1)
  dmux2/1(out) -> dout2/1
  din3/1 -> delay3/1
  reo_in3/1 -> complex_conj3/1(z)
  sel_replicate3/1(out) -> dmux3/1(sel)
  delay3/1 -> dmux3/2(d0)
  complex_conj3/1(z*) -> dmux3/3(d1)
  dmux3/1(out) -> dout3/1
