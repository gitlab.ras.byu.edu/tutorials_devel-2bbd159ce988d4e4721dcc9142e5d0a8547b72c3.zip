simulink model "roach2_tut_corr"  (R2013b)
settings: Solver=VariableStepDiscrete  SolverMode=SingleTasking  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): add_latency, addr_width, Bit, bitfield, BitWidth, bram_latency, burst_size, casper_library_scopes, conv_latency, data_width, DelayLen, fan_latency, FFTSize, FFTStage, getfield, increment, led, Location, Lower, mult_latency, mux_latency, n_bits, n_bits_data, n_inputs, n_streams, n_taps, neg_latency, negate_latency, nsamples, pfb_size, pulse_len, reset_period, ROACH, ROACH2, snapshot, sx475t, sync_period, sync_period_bits, Upper, UseCounter, Width
libraries: xbsIndex_r4 x24444, casper_library_misc x73, xbsReplacements_r4 x34, casper_library_delays x14, xps_library x7
(part 39 of 116)

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_6/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=8  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_6/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=8  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  dbl_ovrd=off  reg_retiming=on  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/delay0 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/delay1 ==
  din : Inport
  del{1..4} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  dbl_ovrd=off  reg_retiming=on  block_type=delay
  din_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand
  dout_compress : Subsystem  AncestorBlock=casper_library_flow_control/bus_create
  dout : Outport
  wires:
  din/1 -> din_expand/1(bus_in)
  din_expand/1(msb_out4) -> del1/1
  din_expand/2(out3) -> del2/1
  din_expand/3(out2) -> del3/1
  din_expand/4(lsb_out1) -> del4/1
  del1/1 -> dout_compress/1(in1)
  del2/1 -> dout_compress/2(in2)
  del3/1 -> dout_compress/3(in3)
  del4/1 -> dout_compress/4(in4)
  dout_compress/1(bus_out) -> dout/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_add/a_debus ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-270  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-252  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-234  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-198  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-180  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-162  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_add/b_debus ==
  bus_in : Inport
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-285  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-114  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-95  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-76  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice13 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-57  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice14 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-38  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice15 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-19  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice16 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-266  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-247  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-228  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-209  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-190  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-171  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-152  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-133  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out16 : Outport
  out15 : Outport  Port=2
  out14 : Outport  Port=3
  out13 : Outport  Port=4
  out12 : Outport  Port=5
  out11 : Outport  Port=6
  out10 : Outport  Port=7
  out9 : Outport  Port=8
  out8 : Outport  Port=9
  out7 : Outport  Port=10
  out6 : Outport  Port=11
  out5 : Outport  Port=12
  out4 : Outport  Port=13
  out3 : Outport  Port=14
  out2 : Outport  Port=15
  lsb_out1 : Outport  Port=16
  wires:
  bus_in/1 -> slice16/1, slice15/1, slice14/1, slice13/1, slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice16/1 -> reinterpret16/1
  reinterpret16/1 -> msb_out16/1
  slice15/1 -> reinterpret15/1
  reinterpret15/1 -> out15/1
  slice14/1 -> reinterpret14/1
  reinterpret14/1 -> out14/1
  slice13/1 -> reinterpret13/1
  reinterpret13/1 -> out13/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_add/op_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  concatenate : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  reinterpret{1..16} (16 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  in13 : Inport  Port=13
  in14 : Inport  Port=14
  in15 : Inport  Port=15
  in16 : Inport  Port=16
  in17 : Inport  Port=17
  in18 : Inport  Port=18
  in19 : Inport  Port=19
  in20 : Inport  Port=20
  in21 : Inport  Port=21
  in22 : Inport  Port=22
  in23 : Inport  Port=23
  in24 : Inport  Port=24
  in25 : Inport  Port=25
  in26 : Inport  Port=26
  in27 : Inport  Port=27
  in28 : Inport  Port=28
  in29 : Inport  Port=29
  in30 : Inport  Port=30
  in31 : Inport  Port=31
  in32 : Inport  Port=32
  concatenate : xbsIndex_r4/Concat  num_inputs=32  dbl_ovrd=off  block_type=concat
  reinterpret{1..32} (32 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12
  in13/1 -> reinterpret13/1
  reinterpret13/1 -> concatenate/13
  in14/1 -> reinterpret14/1
  reinterpret14/1 -> concatenate/14
  in15/1 -> reinterpret15/1
  reinterpret15/1 -> concatenate/15
  in16/1 -> reinterpret16/1
  reinterpret16/1 -> concatenate/16
  in17/1 -> reinterpret17/1
  reinterpret17/1 -> concatenate/17
  in18/1 -> reinterpret18/1
  reinterpret18/1 -> concatenate/18
  in19/1 -> reinterpret19/1
  reinterpret19/1 -> concatenate/19
  in20/1 -> reinterpret20/1
  reinterpret20/1 -> concatenate/20
  in21/1 -> reinterpret21/1
  reinterpret21/1 -> concatenate/21
  in22/1 -> reinterpret22/1
  reinterpret22/1 -> concatenate/22
  in23/1 -> reinterpret23/1
  reinterpret23/1 -> concatenate/23
  in24/1 -> reinterpret24/1
  reinterpret24/1 -> concatenate/24
  in25/1 -> reinterpret25/1
  reinterpret25/1 -> concatenate/25
  in26/1 -> reinterpret26/1
  reinterpret26/1 -> concatenate/26
  in27/1 -> reinterpret27/1
  reinterpret27/1 -> concatenate/27
  in28/1 -> reinterpret28/1
  reinterpret28/1 -> concatenate/28
  in29/1 -> reinterpret29/1
  reinterpret29/1 -> concatenate/29
  in30/1 -> reinterpret30/1
  reinterpret30/1 -> concatenate/30
  in31/1 -> reinterpret31/1
  reinterpret31/1 -> concatenate/31
  in32/1 -> reinterpret32/1
  reinterpret32/1 -> concatenate/32

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv1 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv10 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv11 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv12 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv13 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv14 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv15 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv16 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv17 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system roach2_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert/conv18 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1
