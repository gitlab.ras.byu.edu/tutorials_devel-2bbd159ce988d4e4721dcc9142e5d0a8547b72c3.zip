simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 18 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/pol2_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/pol3_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c0 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c1 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c2 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c3 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c4 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/ri_to_c5 ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/abus ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  concatenate : xbsIndex_r4/Concat  num_inputs=6  dbl_ovrd=off  block_type=concat
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6

== system snap_tut_corr/fft_wideband_real/fft_direct/adebus0_0 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/adebus1_0 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/adebus1_1 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/bbus ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  concatenate : xbsIndex_r4/Concat  num_inputs=6  dbl_ovrd=off  block_type=concat
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6

== system snap_tut_corr/fft_wideband_real/fft_direct/bdebus0_0 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/bdebus1_0 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/bdebus1_1 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0 ==
  a : Inport
  b : Inport  Port=2
  sync_in : Inport  Port=3
  shift : Inport  Port=4
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_add : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=0, n_bits_a=[18 18 18 18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[19 19 19 19 19 19], bin_pt_b=17, type_b=1, cmplx=on, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=20, bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=behavioral HDL, csp_latency=1, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[21 21 21 21 21 21 21 21 21 21 21 21], bin_pt_in=[18 18 18 18 18 18 18 18 18 18 18 18], cmplx=on, n_bits_out=18, bin_pt_out=17, quantization=2, overflow=0, csp_latency=conv_latency, of=on, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=[216 216], outputBinaryPt=[0,0], outputArithmeticType=[0,0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_norm0 : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[20 20 20 20 20 20 20 20 20 20 20 20], bin_pt_in=[17 17 17 17 17 17 17 17 17 17 17 17], cmplx=on, n_bits_out=21, bin_pt_out=18, quantization=0, overflow=0, csp_latency=0, of=off, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_norm1 : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[20 20 20 20 20 20 20 20 20 20 20 20], bin_pt_in=[18 18 18 18 18 18 18 18 18 18 18 18], cmplx=on, n_bits_out=21, bin_pt_out=18, quantization=0, overflow=0, csp_latency=0, of=off, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_relational : Subsystem  AncestorBlock=casper_library_bus/bus_relational  mask(bus_relational){n_bits_a=4, bin_pt_a=0, type_a=0, n_bits_b=[4 4 4 4 4 4], bin_pt_b=0, type_b=0, en=off, misc=off, mode=a!=b, csp_latency=1}
      mask prompts: n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; en "en port"; misc "misc support"; mode "comparison:"; csp_latency "latency"
      mask help: Find the relational product of two busses
      mask init:
      | bus_relational_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'en', en, ...
      |     'misc', misc, ...
      |     'mode', mode, ...
      |     'csp_latency', csp_latency);
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale  mask(bus_scale){n_bits_in=[20 20 20 20 20 20 20 20 20 20 20 20], bin_pt_in=17, type_in=1, cmplx=on, scale_factor=-1, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; type_in "input types"; cmplx "input complex"; scale_factor "scale factor (2^?)"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_scale_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'type_in', type_in, ...
      |     'cmplx', cmplx, ...
      |     'scale_factor', scale_factor, ...
      |     'misc', misc);
  bus_sub : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=1, n_bits_a=[18 18 18 18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[19 19 19 19 19 19], bin_pt_b=17, type_b=1, cmplx=on, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=20, bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=behavioral HDL, csp_latency=1, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency+2+conv_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=12, div_size=[2 2 2 2 2 2 2 2 2 2 2 2], order=[0 6 1 7 2 8 3 9 4 10 5 11], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  mux : Subsystem  AncestorBlock=casper_library_bus/bus_mux  mask(bus_mux){n_inputs=2, n_bits=[21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21], cmplx=off, misc=off, mux_latency=2}
      mask prompts: n_inputs "number of inputs"; n_bits "input bit widths"; cmplx "complex data"; misc "misc support"; mux_latency "mux latency"
      mask help: Mux components of bus
      mask init:
      | bus_mux_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'mux_latency', mux_latency);
  shift_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=24, csp_latency=2, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  twiddle : Subsystem  AncestorBlock=casper_library_ffts_twiddle/twiddle_general  mask(twiddle_general){n_inputs=6, FFTSize=11, Coeffs=[0 256 128 384 64 320 192 448 32 288 160 416 96 352 224 480 16 272 144 400 80 336 208 464 48 304 176 432 112 368 240 496 8 264 136 392 72 328 200 456 40 296 168 424 104 360 232 488 24 280 152 408 88 344 216 472 56 312 184 440 120 376 248 504 4 260 132 388 68 324 196 452 36 292 164 420 100 356 228 484 20 276 148 404 84 340 212 468 52 308 180 436 116 372 244 500 12 268 140 396 76 332 204 460 44 300 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, StepPeriod=0, coeff_bit_width=18, input_bit_width=18, bin_pt_in=17, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=8, use_hdl=on, use_embedded=off, quantization=Round  (unbiased: Even Values), overflow=Wrap}
      mask prompts: n_inputs "Number inputs"; FFTSize "FFT Size (2^?)"; Coeffs "Coefficients:"; StepPeriod "Coefficient Step Period (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert Latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; quantization "Quantization Behavior"; overflow "Overflow Behavior"
      mask help: Used in biplex pipelined FFT.
      mask init:
      | twiddle_general_init(gcb, ...
      |     'FFTSize', FFTSize, ...
      |     'async', async, ...
      |     'n_inputs', n_inputs, ...
      |     'Coeffs', Coeffs, ...
      |     'StepPeriod', StepPeriod, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...      
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'coeff_generation', coeff_generation, ...
      |     'cal_bits', cal_bits, ...
      |     'n_bits_rotation', n_bits_rotation, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow)
  a+bw : Outport
  a-bw : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  a/1 -> twiddle/1(ai)
  b/1 -> twiddle/2(bi)
  sync_in/1 -> twiddle/3(sync_in)
  twiddle/1(ao) -> bus_add/1(a), bus_sub/1(a)
  twiddle/2(bwo) -> bus_add/2(b), bus_sub/2(b)
  bus_add/1(dout) -> Concat/1
  bus_sub/1(dout) -> Concat/2
  shift/1 -> shift_replicate/1(in)
  Concat/1 -> bus_norm0/1(din), bus_scale/1(din)
  bus_scale/1(dout) -> bus_norm1/1(din)
  shift_replicate/1(out) -> mux/1(sel)
  bus_norm0/1(dout) -> mux/2(d0)
  bus_norm1/1(dout) -> mux/3(d1)
  mux/1(out) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> a+bw/1
  bus_expand/2(lsb_out1) -> a-bw/1
  bus_convert/2(overflow) -> munge/1(din)
  constant/1 -> bus_relational/1(a)
  munge/1(dout) -> bus_relational/2(b)
  bus_relational/1(a!=b) -> of/1
  twiddle/3(sync_out) -> delay0/1
  delay0/1 -> sync_out/1
