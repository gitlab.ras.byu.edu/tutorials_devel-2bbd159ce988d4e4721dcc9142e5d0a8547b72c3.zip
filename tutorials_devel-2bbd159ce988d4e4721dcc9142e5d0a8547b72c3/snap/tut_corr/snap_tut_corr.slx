simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 9 of 131)

== system snap_tut_corr/quant2/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=10, data_width=32, data_bin_pt=0, init_vals=[0     1     2     3     4     5     6     7     8     9    10    11    12    13    14    15    16    17    18    19    20    21    22    23    24    25    26    27    28    29    30    31    32    33    34    35    36    37    38    39    40    41    42    43    44    45    46    47    48    49    50    51    52    53    54    55    56    57    58    59    60    61    62    63    64    65    66  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_quant2_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant2_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant2_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_quant2_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_quant2_coeffs_data_out/1
  snap_tut_corr_quant2_coeffs_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_quant2_coeffs_addr/1
  convert_din1/1 -> snap_tut_corr_quant2_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_quant2_coeffs_we/1 -> Terminator2/1
  snap_tut_corr_quant2_coeffs_data_in/1 -> Terminator1/1
  snap_tut_corr_quant2_coeffs_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_quant2_coeffs_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/quant2/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/quant2/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/snapshot_eq/buscreate ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/snapshot_eq/ss ==
  note: Generate stop when in circular capture mode
  note: Delay start of capture
  note: ctrl: bit0: Put a posedge here to enable a new capture. bit1: ignore external trigger and trigger immediately. bit2: ignore external write enable and capture on every FPGA clock. bit3: continuously capture data until we get an external stop command.
  note: Offset in vector from first element captured, used during circular capture
  note: Number of bytes in buffer and done bit
  note: Number of valid data samples to skip after trigger before starting capture
  note: Value on vin aligned with first sample on din captured
  din : Inport
  we : Inport  Port=2
  trig : Inport  Port=3
  add_del : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  add_gen : Subsystem  AncestorBlock=casper_library_scopes/snapshot/add_gen  mask{counter_size=10+3+1, increment=8, nsamples=10, burst_size=0, use_dsp48=on}
      mask prompts: counter_size "Address counter size (2^?)"; increment "Address counter increment"; nsamples "Number of samples (2^?)"; burst_size "Burst size (2^?)"; use_dsp48 "dsp48 counter/s"
      mask init:
      | set_param(gcb,'LinkStatus','inactive');
      | if strcmp(use_dsp48,'on'),
      |     set_param([gcb,'/add_gen'],'implementation','DSP48');
      | else
      |     set_param([gcb,'/add_gen'],'implementation','Fabric');
      | end
  arm : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  arm_or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  basic_ctrl : Subsystem  AncestorBlock=casper_library_scopes/snapshot/basic_ctrl  mask{dram=off, data_width=64}
      mask prompts: data_width "data width"
      mask init:
      | set_param(gcb,'LinkStatus','inactive');
      | set_param([gcb,'/dram_munge'], 'dram', dram);
  bram : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=10, data_width=64, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=[0:2^10-1], sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  cast : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=64  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  circ : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  circ_or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  ctrl : Subsystem  Tag=xps:sw_reg  AncestorBlock=xps_library/Memory/software_register  mask(swreg){io_dir=From Processor, io_delay=0, init_val=0, sample_period=1, names=reg, bitwidths=32, bin_pts=0, arith_types=0, sim_port=off, show_format=on}
      mask prompts: io_dir "I/O direction"; io_delay "I/O delay"; init_val "Initial Value"; sample_period "Sample period"; names "Bitfield names [msb...lsb]"; bitwidths "Bitfield widths"; bin_pts "Bitfield binary pts"; arith_types "Bitfield types, ufix=0, fix=1, bool=2"; sim_port "Provide sim input/output?"; show_format "Print format string?"
      mask help: A 32-bit software-accessible register. Can be divided into bitfields of varying widths and types using the fields in the block mask.
      mask init:
      | swreg_init(gcb)
  ctrl_combine : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=4}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  ctrl_split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[28 1 2 1], outputBinaryPt=0, outputArithmeticType=[0 2 0 2], show_format=on, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dat_del : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  g_tr_en_cnt : Terminator
  gbram : Terminator
  goto_ss_we2_const : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  goto_ss_we3_const : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  gval : Terminator
  never : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  ri : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  status : Subsystem  Tag=xps:sw_reg  AncestorBlock=xps_library/Memory/software_register  mask(swreg){io_dir=To Processor, io_delay=0, init_val=0, sample_period=1, names=reg, bitwidths=32, bin_pts=0, arith_types=0, sim_port=off, show_format=on}
      mask prompts: io_dir "I/O direction"; io_delay "I/O delay"; init_val "Initial Value"; sample_period "Sample period"; names "Bitfield names [msb...lsb]"; bitwidths "Bitfield widths"; bin_pts "Bitfield binary pts"; arith_types "Bitfield types, ufix=0, fix=1, bool=2"; sim_port "Provide sim input/output?"; show_format "Print format string?"
      mask help: A 32-bit software-accessible register. Can be divided into bitfields of varying widths and types using the fields in the block mask.
      mask init:
      | swreg_init(gcb)
  vin_const : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  we_del : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  arm_out : Outport
  wires:
  din/1 -> ri/1
  ri/1 -> cast/1
  cast/1 -> basic_ctrl/2(din)
  we/1 -> basic_ctrl/3(we)
  trig/1 -> basic_ctrl/4(trig)
  ctrl_combine/1(bus_out) -> basic_ctrl/5(ctrl)
  never/1 -> basic_ctrl/6(stopi)
  arm/1 -> arm_or/2
  arm_or/1 -> arm_out/1, ctrl_combine/4(in4)
  circ/1 -> circ_or/2
  ctrl/1(in_reg) -> ctrl_split/1(bus_in)
  ctrl_split/1(msb_out4) -> ctrl_combine/1(in1)
  ctrl_split/2(out3) -> circ_or/1
  ctrl_split/3(out2) -> ctrl_combine/3(in3)
  ctrl_split/4(lsb_out1) -> arm_or/1
  circ_or/1 -> ctrl_combine/2(in2)
  basic_ctrl/1(vout) -> add_gen/1(vin)
  basic_ctrl/2(dout) -> add_gen/2(din)
  basic_ctrl/3(we_o) -> add_gen/3(we), [goto_30273884_we1]
  basic_ctrl/4(go) -> add_gen/4(go)
  basic_ctrl/5(stop) -> add_gen/5(cont)
  basic_ctrl/6(init) -> add_gen/6(init)
  add_gen/5(status) -> status/1(out_reg)
  vin_const/1 -> basic_ctrl/1(vin)
  add_gen/1(vout) -> gval/1
  add_gen/6(en_cnt) -> g_tr_en_cnt/1
  add_gen/2(add) -> add_del/1
  add_gen/3(dout) -> dat_del/1
  add_gen/4(we_o) -> we_del/1, [goto_30273884_we4]
  add_del/1 -> bram/1(addr)
  dat_del/1 -> bram/2(data_in)
  we_del/1 -> bram/3(we)
  bram/1(data_out) -> gbram/1
  goto_ss_we2_const/1 -> [goto_30273884_we2]
  goto_ss_we3_const/1 -> [goto_30273884_we3]

== system snap_tut_corr/sync_gen/rst_gen ==
  arm : Inport
  sync_in : Inport  Port=2
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=ceil(log2(reset_period+1))+1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=0  operation=Down  start_count=reset_period+1  cnt_by_val=1  arith_type=Unsigned  n_bits=ceil(log2(reset_period+1))+1  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  mrst : Outport
  wires:
  arm/1 -> Counter/1
  Counter/1 -> Relational/1
  Constant/1 -> Relational/2
  sync_in/1 -> Logical/1
  Relational/1 -> mrst/1, Logical/2
  Logical/1 -> Counter/2

== system snap_tut_corr/sync_gen/sync_gen ==
  rst : Inport
  sync_period : Inport  Port=2
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Logical : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Relational : xbsIndex_r4/Relational  mode=a>=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  edge_detect1 : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Falling, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[1  1 -1 -1 -1 -1 -1 -1 -1 -1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1 -1 -1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  edge_detect2 : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Rising, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1  1  1  1  1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1 -1 -1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  sync_count : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=3  cnt_by_val=1  arith_type=Unsigned  n_bits=sync_gen_bits  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  sync : Outport
  wires:
  Delay/1 -> Logical/1
  edge_detect2/1(out) -> Logical/2, Logical1/2
  sync_period/1 -> Relational/2
  Logical1/1 -> sync/1
  rst/1 -> Delay/1, edge_detect1/1(in)
  edge_detect1/1(out) -> Logical1/1
  Logical/1 -> sync_count/1
  Relational/1 -> edge_detect2/1(in)
  sync_count/1 -> Relational/1

== system snap_tut_corr/dir_x0/aa/c_to_ri ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1

== system snap_tut_corr/dir_x0/aa/c_to_ri1 ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1
