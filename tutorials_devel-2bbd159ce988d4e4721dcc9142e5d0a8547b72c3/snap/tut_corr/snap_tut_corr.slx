simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 33 of 131)

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv17 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv18 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv19 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv20 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv21 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv22 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv23 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv24 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out24) -> conv1/1(in)
  debus/2(out23) -> conv2/1(in)
  debus/3(out22) -> conv3/1(in)
  debus/4(out21) -> conv4/1(in)
  debus/5(out20) -> conv5/1(in)
  debus/6(out19) -> conv6/1(in)
  debus/7(out18) -> conv7/1(in)
  debus/8(out17) -> conv8/1(in)
  debus/9(out16) -> conv9/1(in)
  debus/10(out15) -> conv10/1(in)
  debus/11(out14) -> conv11/1(in)
  debus/12(out13) -> conv12/1(in)
  debus/13(out12) -> conv13/1(in)
  debus/14(out11) -> conv14/1(in)
  debus/15(out10) -> conv15/1(in)
  debus/16(out9) -> conv16/1(in)
  debus/17(out8) -> conv17/1(in)
  debus/18(out7) -> conv18/1(in)
  debus/19(out6) -> conv19/1(in)
  debus/20(out5) -> conv20/1(in)
  debus/21(out4) -> conv21/1(in)
  debus/22(out3) -> conv22/1(in)
  debus/23(out2) -> conv23/1(in)
  debus/24(lsb_out1) -> conv24/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  conv13/1(out) -> bussify/13(in13)
  conv14/1(out) -> bussify/14(in14)
  conv15/1(out) -> bussify/15(in15)
  conv16/1(out) -> bussify/16(in16)
  conv17/1(out) -> bussify/17(in17)
  conv18/1(out) -> bussify/18(in18)
  conv19/1(out) -> bussify/19(in19)
  conv20/1(out) -> bussify/20(in20)
  conv21/1(out) -> bussify/21(in21)
  conv22/1(out) -> bussify/22(in22)
  conv23/1(out) -> bussify/23(in23)
  conv24/1(out) -> bussify/24(in24)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4], outputBinaryPt=[0], outputArithmeticType=[0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4  4  4  4  4  4], outputBinaryPt=[0  0  0  0  0  0], outputArithmeticType=[0  0  0  0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  relational{1..6} (6 alike) : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1, relational4/1, relational5/1, relational6/1
  b_debus/1(msb_out6) -> relational1/2
  b_debus/2(out5) -> relational2/2
  b_debus/3(out4) -> relational3/2
  b_debus/4(out3) -> relational4/2
  b_debus/5(out2) -> relational5/2
  b_debus/6(lsb_out1) -> relational6/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  relational4/1 -> bussify/4(in4)
  relational5/1 -> bussify/5(in5)
  relational6/1 -> bussify/6(in6)
  bussify/1(bus_out) -> a!=b/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  scale{1..24} (24 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out24) -> scale1/1
  debus/2(out23) -> scale2/1
  debus/3(out22) -> scale3/1
  debus/4(out21) -> scale4/1
  debus/5(out20) -> scale5/1
  debus/6(out19) -> scale6/1
  debus/7(out18) -> scale7/1
  debus/8(out17) -> scale8/1
  debus/9(out16) -> scale9/1
  debus/10(out15) -> scale10/1
  debus/11(out14) -> scale11/1
  debus/12(out13) -> scale12/1
  debus/13(out12) -> scale13/1
  debus/14(out11) -> scale14/1
  debus/15(out10) -> scale15/1
  debus/16(out9) -> scale16/1
  debus/17(out8) -> scale17/1
  debus/18(out7) -> scale18/1
  debus/19(out6) -> scale19/1
  debus/20(out5) -> scale20/1
  debus/21(out4) -> scale21/1
  debus/22(out3) -> scale22/1
  debus/23(out2) -> scale23/1
  debus/24(lsb_out1) -> scale24/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  scale13/1 -> bussify/13(in13)
  scale14/1 -> bussify/14(in14)
  scale15/1 -> bussify/15(in15)
  scale16/1 -> bussify/16(in16)
  scale17/1 -> bussify/17(in17)
  scale18/1 -> bussify/18(in18)
  scale19/1 -> bussify/19(in19)
  scale20/1 -> bussify/20(in20)
  scale21/1 -> bussify/21(in21)
  scale22/1 -> bussify/22(in22)
  scale23/1 -> bussify/23(in23)
  scale24/1 -> bussify/24(in24)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18  18  18  18  18  18  18  18  18  18  18  18], outputBinaryPt=[17  17  17  17  17  17  17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1  1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addsub{1..12} (12 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  dbl_ovrd=off  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[19  19  19  19  19  19  19  19  19  19  19  19], outputBinaryPt=[17  17  17  17  17  17  17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1  1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out12) -> addsub1/1
  b_debus/1(msb_out12) -> addsub1/2
  a_debus/2(out11) -> addsub2/1
  b_debus/2(out11) -> addsub2/2
  a_debus/3(out10) -> addsub3/1
  b_debus/3(out10) -> addsub3/2
  a_debus/4(out9) -> addsub4/1
  b_debus/4(out9) -> addsub4/2
  a_debus/5(out8) -> addsub5/1
  b_debus/5(out8) -> addsub5/2
  a_debus/6(out7) -> addsub6/1
  b_debus/6(out7) -> addsub6/2
  a_debus/7(out6) -> addsub7/1
  b_debus/7(out6) -> addsub7/2
  a_debus/8(out5) -> addsub8/1
  b_debus/8(out5) -> addsub8/2
  a_debus/9(out4) -> addsub9/1
  b_debus/9(out4) -> addsub9/2
  a_debus/10(out3) -> addsub10/1
  b_debus/10(out3) -> addsub10/2
  a_debus/11(out2) -> addsub11/1
  b_debus/11(out2) -> addsub11/2
  a_debus/12(lsb_out1) -> addsub12/1
  b_debus/12(lsb_out1) -> addsub12/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  addsub7/1 -> op_bussify/7(in7)
  addsub8/1 -> op_bussify/8(in8)
  addsub9/1 -> op_bussify/9(in9)
  addsub10/1 -> op_bussify/10(in10)
  addsub11/1 -> op_bussify/11(in11)
  addsub12/1 -> op_bussify/12(in12)
  op_bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[2 2 2 2 2 2 2 2 2 2 2 2], outputBinaryPt=[0 0 0 0 0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0 0 0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out12) -> join/1(in1)
  split/7(out6) -> join/2(in2)
  split/2(out11) -> join/3(in3)
  split/8(out5) -> join/4(in4)
  split/3(out10) -> join/5(in5)
  split/9(out4) -> join/6(in6)
  split/4(out9) -> join/7(in7)
  split/10(out3) -> join/8(in8)
  split/5(out8) -> join/9(in9)
  split/11(out2) -> join/10(in10)
  split/6(out7) -> join/11(in11)
  split/12(lsb_out1) -> join/12(in12)

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/mux ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0], outputArithmeticType=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0], outputArithmeticType=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux{0..23} (24 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=24, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out24) -> mux0/1
  expand0/1(msb_out24) -> mux0/2
  expand1/1(msb_out24) -> mux0/3
  sel_expand/2(out23) -> mux1/1
  expand0/2(out23) -> mux1/2
  expand1/2(out23) -> mux1/3
  sel_expand/3(out22) -> mux2/1
  expand0/3(out22) -> mux2/2
  expand1/3(out22) -> mux2/3
  sel_expand/4(out21) -> mux3/1
  expand0/4(out21) -> mux3/2
  expand1/4(out21) -> mux3/3
  sel_expand/5(out20) -> mux4/1
  expand0/5(out20) -> mux4/2
  expand1/5(out20) -> mux4/3
  sel_expand/6(out19) -> mux5/1
  expand0/6(out19) -> mux5/2
  expand1/6(out19) -> mux5/3
  sel_expand/7(out18) -> mux6/1
  expand0/7(out18) -> mux6/2
  expand1/7(out18) -> mux6/3
  sel_expand/8(out17) -> mux7/1
  expand0/8(out17) -> mux7/2
  expand1/8(out17) -> mux7/3
  sel_expand/9(out16) -> mux8/1
  expand0/9(out16) -> mux8/2
  expand1/9(out16) -> mux8/3
  sel_expand/10(out15) -> mux9/1
  expand0/10(out15) -> mux9/2
  expand1/10(out15) -> mux9/3
  sel_expand/11(out14) -> mux10/1
  expand0/11(out14) -> mux10/2
  expand1/11(out14) -> mux10/3
  sel_expand/12(out13) -> mux11/1
  expand0/12(out13) -> mux11/2
  expand1/12(out13) -> mux11/3
  sel_expand/13(out12) -> mux12/1
  expand0/13(out12) -> mux12/2
  expand1/13(out12) -> mux12/3
  sel_expand/14(out11) -> mux13/1
  expand0/14(out11) -> mux13/2
  expand1/14(out11) -> mux13/3
  sel_expand/15(out10) -> mux14/1
  expand0/15(out10) -> mux14/2
  expand1/15(out10) -> mux14/3
  sel_expand/16(out9) -> mux15/1
  expand0/16(out9) -> mux15/2
  expand1/16(out9) -> mux15/3
  sel_expand/17(out8) -> mux16/1
  expand0/17(out8) -> mux16/2
  expand1/17(out8) -> mux16/3
  sel_expand/18(out7) -> mux17/1
  expand0/18(out7) -> mux17/2
  expand1/18(out7) -> mux17/3
  sel_expand/19(out6) -> mux18/1
  expand0/19(out6) -> mux18/2
  expand1/19(out6) -> mux18/3
  sel_expand/20(out5) -> mux19/1
  expand0/20(out5) -> mux19/2
  expand1/20(out5) -> mux19/3
  sel_expand/21(out4) -> mux20/1
  expand0/21(out4) -> mux20/2
  expand1/21(out4) -> mux20/3
  sel_expand/22(out3) -> mux21/1
  expand0/22(out3) -> mux21/2
  expand1/22(out3) -> mux21/3
  sel_expand/23(out2) -> mux22/1
  expand0/23(out2) -> mux22/2
  expand1/23(out2) -> mux22/3
  sel_expand/24(lsb_out1) -> mux23/1
  expand0/24(lsb_out1) -> mux23/2
  expand1/24(lsb_out1) -> mux23/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  mux4/1 -> d_bussify/5(in5)
  mux5/1 -> d_bussify/6(in6)
  mux6/1 -> d_bussify/7(in7)
  mux7/1 -> d_bussify/8(in8)
  mux8/1 -> d_bussify/9(in9)
  mux9/1 -> d_bussify/10(in10)
  mux10/1 -> d_bussify/11(in11)
  mux11/1 -> d_bussify/12(in12)
  mux12/1 -> d_bussify/13(in13)
  mux13/1 -> d_bussify/14(in14)
  mux14/1 -> d_bussify/15(in15)
  mux15/1 -> d_bussify/16(in16)
  mux16/1 -> d_bussify/17(in17)
  mux17/1 -> d_bussify/18(in18)
  mux18/1 -> d_bussify/19(in19)
  mux19/1 -> d_bussify/20(in20)
  mux20/1 -> d_bussify/21(in21)
  mux21/1 -> d_bussify/22(in22)
  mux22/1 -> d_bussify/23(in23)
  mux23/1 -> d_bussify/24(in24)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/shift_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_{0..23} (24 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1
  din0_0/1 -> din1_0/1, din1_4/1, din1_8/1, din1_12/1, din1_16/1, din1_20/1
  din0_1/1 -> din1_1/1, din1_5/1, din1_9/1, din1_13/1, din1_17/1, din1_21/1
  din0_2/1 -> din1_2/1, din1_6/1, din1_10/1, din1_14/1, din1_18/1, din1_22/1
  din0_3/1 -> din1_3/1, din1_7/1, din1_11/1, din1_15/1, din1_19/1, din1_23/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  din1_3/1 -> bussify/4(in4)
  din1_4/1 -> bussify/5(in5)
  din1_5/1 -> bussify/6(in6)
  din1_6/1 -> bussify/7(in7)
  din1_7/1 -> bussify/8(in8)
  din1_8/1 -> bussify/9(in9)
  din1_9/1 -> bussify/10(in10)
  din1_10/1 -> bussify/11(in11)
  din1_11/1 -> bussify/12(in12)
  din1_12/1 -> bussify/13(in13)
  din1_13/1 -> bussify/14(in14)
  din1_14/1 -> bussify/15(in15)
  din1_15/1 -> bussify/16(in16)
  din1_16/1 -> bussify/17(in17)
  din1_17/1 -> bussify/18(in18)
  din1_18/1 -> bussify/19(in19)
  din1_19/1 -> bussify/20(in20)
  din1_20/1 -> bussify/21(in21)
  din1_21/1 -> bussify/22(in22)
  din1_22/1 -> bussify/23(in23)
  din1_23/1 -> bussify/24(in24)
  bussify/1(bus_out) -> out/1
