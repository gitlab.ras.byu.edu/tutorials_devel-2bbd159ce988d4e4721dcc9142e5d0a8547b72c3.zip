simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 23 of 131)

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/tap_delays ==
  addra : Inport
  dina : Inport  Port=2
  wea : Inport  Port=3
  addrb : Inport  Port=4
  dinb : Inport  Port=5
  web : Inport  Port=6
  A_bussify0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=8}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  B_bussify0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=8}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  alsbs_slice : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  blsbs_slice : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  bram0_{0..7} (8 alike) : xbsIndex_r4/Dual Port RAM  depth=512  initVector=getfield(get_param(gcb, 'UserData'), 'initVector')  distributed_mem=Block RAM  init_a=0  init_b=0  rst_a=off  rst_b=off  en_a=off  en_b=off  latency=1  write_mode_A=Read Before Write  write_mode_B=Read Before Write  optimize=Area  dbl_ovrd=off  block_type=dpram
  ddina0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  ddinb0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  debus_addra0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=[9 9 9 9 9 9 9 9], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus_addrb0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=[9 9 9 9 9 9 9 9], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus_dina0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36 36 36 36 36 36], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus_dinb0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36 36 36 36 36 36], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus_wea0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=[1 1 1 1 1 1 1 1], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[2 2 2 2 2 2 2 2], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus_web0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=[1 1 1 1 1 1 1 1], outputBinaryPt=[0 0 0 0 0 0 0 0], outputArithmeticType=[2 2 2 2 2 2 2 2], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  rep_addra0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=8, csp_latency=1, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  rep_addrb0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=8, csp_latency=1, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  rep_wea0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=8, csp_latency=0, misc=off, implementation=behavioral}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  rep_web0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=8, csp_latency=1, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  A : Outport
  B : Outport  Port=2
  wires:
  addrb/1 -> blsbs_slice/1
  addra/1 -> alsbs_slice/1
  blsbs_slice/1 -> rep_addrb0/1(in)
  alsbs_slice/1 -> rep_addra0/1(in)
  dina/1 -> ddina0/1
  wea/1 -> rep_wea0/1(in)
  dinb/1 -> ddinb0/1
  web/1 -> rep_web0/1(in)
  rep_addrb0/1(out) -> debus_addrb0/1(bus_in)
  rep_addra0/1(out) -> debus_addra0/1(bus_in)
  ddina0/1 -> debus_dina0/1(bus_in)
  rep_wea0/1(out) -> debus_wea0/1(bus_in)
  ddinb0/1 -> debus_dinb0/1(bus_in)
  rep_web0/1(out) -> debus_web0/1(bus_in)
  debus_addra0/1(msb_out8) -> bram0_0/1
  debus_dina0/1(msb_out8) -> bram0_0/2
  debus_wea0/1(msb_out8) -> bram0_0/3
  debus_addrb0/1(msb_out8) -> bram0_0/4
  debus_dinb0/1(msb_out8) -> bram0_0/5
  debus_web0/1(msb_out8) -> bram0_0/6
  debus_addra0/2(out7) -> bram0_1/1
  debus_dina0/2(out7) -> bram0_1/2
  debus_wea0/2(out7) -> bram0_1/3
  debus_addrb0/2(out7) -> bram0_1/4
  debus_dinb0/2(out7) -> bram0_1/5
  debus_web0/2(out7) -> bram0_1/6
  debus_addra0/3(out6) -> bram0_2/1
  debus_dina0/3(out6) -> bram0_2/2
  debus_wea0/3(out6) -> bram0_2/3
  debus_addrb0/3(out6) -> bram0_2/4
  debus_dinb0/3(out6) -> bram0_2/5
  debus_web0/3(out6) -> bram0_2/6
  debus_addra0/4(out5) -> bram0_3/1
  debus_dina0/4(out5) -> bram0_3/2
  debus_wea0/4(out5) -> bram0_3/3
  debus_addrb0/4(out5) -> bram0_3/4
  debus_dinb0/4(out5) -> bram0_3/5
  debus_web0/4(out5) -> bram0_3/6
  debus_addra0/5(out4) -> bram0_4/1
  debus_dina0/5(out4) -> bram0_4/2
  debus_wea0/5(out4) -> bram0_4/3
  debus_addrb0/5(out4) -> bram0_4/4
  debus_dinb0/5(out4) -> bram0_4/5
  debus_web0/5(out4) -> bram0_4/6
  debus_addra0/6(out3) -> bram0_5/1
  debus_dina0/6(out3) -> bram0_5/2
  debus_wea0/6(out3) -> bram0_5/3
  debus_addrb0/6(out3) -> bram0_5/4
  debus_dinb0/6(out3) -> bram0_5/5
  debus_web0/6(out3) -> bram0_5/6
  debus_addra0/7(out2) -> bram0_6/1
  debus_dina0/7(out2) -> bram0_6/2
  debus_wea0/7(out2) -> bram0_6/3
  debus_addrb0/7(out2) -> bram0_6/4
  debus_dinb0/7(out2) -> bram0_6/5
  debus_web0/7(out2) -> bram0_6/6
  debus_addra0/8(lsb_out1) -> bram0_7/1
  debus_dina0/8(lsb_out1) -> bram0_7/2
  debus_wea0/8(lsb_out1) -> bram0_7/3
  debus_addrb0/8(lsb_out1) -> bram0_7/4
  debus_dinb0/8(lsb_out1) -> bram0_7/5
  debus_web0/8(lsb_out1) -> bram0_7/6
  bram0_0/1 -> A_bussify0/1(in1)
  bram0_0/2 -> B_bussify0/1(in1)
  bram0_1/1 -> A_bussify0/2(in2)
  bram0_1/2 -> B_bussify0/2(in2)
  bram0_2/1 -> A_bussify0/3(in3)
  bram0_2/2 -> B_bussify0/3(in3)
  bram0_3/1 -> A_bussify0/4(in4)
  bram0_3/2 -> B_bussify0/4(in4)
  bram0_4/1 -> A_bussify0/5(in5)
  bram0_4/2 -> B_bussify0/5(in5)
  bram0_5/1 -> A_bussify0/6(in6)
  bram0_5/2 -> B_bussify0/6(in6)
  bram0_6/1 -> A_bussify0/7(in7)
  bram0_6/2 -> B_bussify0/7(in7)
  bram0_7/1 -> A_bussify0/8(in8)
  bram0_7/2 -> B_bussify0/8(in8)
  A_bussify0/1(bus_out) -> A/1
  B_bussify0/1(bus_out) -> B/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/tap_split ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=312  boolean_output=off  mode=Upper Bit Location + Width  bit1=-936  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=312  boolean_output=off  mode=Upper Bit Location + Width  bit1=-624  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=312  boolean_output=off  mode=Upper Bit Location + Width  bit1=-312  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=312  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/quant0/coeffs/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/quant0/coeffs/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant0/coeffs/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant0/coeffs/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/quant1/coeffs/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/quant1/coeffs/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant1/coeffs/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant1/coeffs/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/quant2/coeffs/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/quant2/coeffs/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant2/coeffs/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/quant2/coeffs/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/snapshot_eq/ss/add_gen ==
  note: Force MSbit of count to be '1' by negating busy as counter bit may be '0' or '1'
  note: A total count of bytes written to BRAM since trig
  note: Count of bytes in BRAM as well as done signal
  note: Do one capture by default
  note: prevent one extra write to address 0
  note: To storage
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  go : Inport  Port=4
  cont : Inport  Port=5
  init : Inport  Port=6
  Concat : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  Convert : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32-nsamples-log2(increment)-1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  Delay{,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay7 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=1  dbl_ovrd=off  block_type=inv
  Inverter1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical1 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical2 : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical4 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Logical6 : xbsIndex_r4/Logical  logical_function=AND  inputs=3  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Register3 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register4 : xbsIndex_r4/Register  init=0  rst=off  en=on  dbl_ovrd=off  block_type=register
  Register5 : xbsIndex_r4/Register  init=1  rst=on  en=on  dbl_ovrd=off  block_type=register
  Shift : xbsIndex_r4/Shift  shift_dir=Left  shift_bits=32-nsamples-log2(increment)-1-1  en=off  latency=1  precision=Full  arith_type="Signed  (2's comp)"  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=shift
  add_gen : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1  operation=Up  start_count=0  cnt_by_val=increment  arith_type=Unsigned  n_bits=counter_size  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=DSP48  use_rpm=on  dbl_ovrd=off  block_type=counter
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Both, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1 -1 -1 -1 -1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1  1  1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  edge_detect1 : Subsystem  AncestorBlock=casper_library_scopes/snapshot/add_gen/edge_detect  mask(edge_detect){edge=Both, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1 -1 -1 -1 -1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1  1  1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  slice1 : xbsIndex_r4/Slice  nbits=nsamples+log2(increment)  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=nsamples-burst_size  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=log2(increment)+burst_size  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=nsamples + log2(increment)  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  add : Outport  Port=2
  dout : Outport  Port=3
  we_o : Outport  Port=4
  status : Outport  Port=5
  en_cnt : Outport  Port=6
  done : Outport  Port=7
  wires:
  Delay6/1 -> dout/1
  Delay5/1 -> Delay7/1
  Delay4/1 -> Delay/1, Register3/1, Register3/3, add_gen/1
  Delay3/1 -> Register5/1, Logical4/1
  Delay7/1 -> Register4/1
  Logical1/1 -> Logical6/3
  go/1 -> Logical1/2
  we/1 -> Logical1/1
  Logical4/1 -> Logical6/2
  Inverter/1 -> Concat/2
  slice1/1 -> Delay1/1
  Delay1/1 -> Concat/3
  din/1 -> Delay6/1
  Delay2/1 -> en_cnt/1
  slice2/1 -> add/1
  Convert/1 -> Shift/1
  Concat/1 -> status/1
  Logical6/1 -> add_gen/2, Register3/2, Logical2/1, we_o/1
  init/1 -> Delay4/1
  slice3/1 -> edge_detect/1(in)
  Register5/1 -> Logical6/1, edge_detect1/1(in), Inverter/1, Convert/1
  add_gen/1 -> slice3/1, Delay2/1, slice1/1, slice2/1
  vin/1 -> Delay5/1
  Register3/1 -> Logical2/2
  Logical2/1 -> Register4/2
  Register4/1 -> vout/1
  edge_detect/1(out) -> Register5/3, Inverter1/1
  cont/1 -> Delay3/1
  Inverter1/1 -> Logical4/2
  Delay/1 -> Register5/2
  Shift/1 -> Concat/1
  edge_detect1/1(out) -> done/1

== system snap_tut_corr/snapshot_eq/ss/basic_ctrl ==
  vin : Inport
  din : Inport  Port=2
  we : Inport  Port=3
  trig : Inport  Port=4
  ctrl : Inport  Port=5
  stopi : Inport  Port=6
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  Logical : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Register1 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  Register6 : xbsIndex_r4/Register  init=0  rst=on  en=on  dbl_ovrd=off  block_type=register
  dram_munge : Subsystem  mask{dram=off, data_width=data_width}
      mask prompts: data_width "data width"
      mask init:
      | set_param(gcb,'LinkStatus','inactive');
      | if strcmp(dram,'on'),
      |     set_param([gcb,'/dram'], 'const', '1');
      | else,
      |     set_param([gcb,'/dram'], 'const', '0');
      | end
      | set_param([gcb,'/data_choice'], ...
      |         'precision', 'User Defined', ...
      |         'arith_type', 'Unsigned', ...
      |         'n_bits', num2str(data_width), 'bin_pt', '0', ...
      |         'quantization', 'Truncate', ...
      |         'overflow', 'Wrap');
  edge_detect : casper_library_misc/edge_detect  edge=Rising  polarity=Active High  x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4]  y_in="[-1 -1  1  1  1  1  1  1  1  1]"  x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1]  y_out="[-1 -1  1  1 -1 -1 -1 -1 -1 -1]"
      link override Delay: sg_icon_stat=45,16,1,1,white,blue,0,07b98262,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 16 16 0 ]); patch([17.55 20.44 22.44 24.44 26.44 22.44 19.55 17.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([19.55 22.44 20.44 17.55 19.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([17.55 20.44 22.44 19.55 17.55 ],[6.22 6.22 8.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
      link override Inverter: sg_icon_stat=45,16,1,1,white,blue,0,267846e5,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 16 16 0 ]); patch([17.55 20.44 22.44 24.44 26.44 22.44 19.55 17.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([19.55 22.44 20.44 17.55 19.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([17.55 20.44 22.44 19.55 17.55 ],[6.22 6.22 8.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
      link override edge_op: sg_icon_stat=45,44,2,1,white,blue,0,affe8783,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 44 44 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 44 44 0 ]); patch([8.65 17.32 23.32 29.32 35.32 23.32 14.65 8.65 ],[28.66 28.66 34.66 28.66 34.66 34.66 34.66 28.66 ],[1 1 1 ]); patch([14.65 23.32 17.32 8.65 14.65 ],[22.66 22.66 28.66 28.66 22.66 ],[0.931 0.946 0.973 ]); patch([8.65 17.32 23.32 14.65 8.65 ],[16.66 16.66 22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
  enable : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  trig_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  valid_src : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=LSB of Input  bit0=2  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  vout : Outport
  dout : Outport  Port=2
  we_o : Outport  Port=3
  go : Outport  Port=4
  stop : Outport  Port=5
  init : Outport  Port=6
  wires:
  Delay1/1 -> edge_detect/1
  Delay3/1 -> Mux1/1
  Delay2/1 -> Mux2/1
  dram_munge/1(vout) -> vout/1
  vin/1 -> dram_munge/1(vin)
  dram_munge/3(we_o) -> we_o/1
  dram_munge/2(dout) -> dout/1
  din/1 -> dram_munge/2(din)
  Inverter/1 -> Logical/2
  Mux2/1 -> Logical/1, Register6/1
  Register6/1 -> go/1
  trig/1 -> Mux2/2
  Mux1/1 -> dram_munge/3(we)
  we/1 -> Mux1/2
  ctrl/1 -> enable/1, valid_src/1, trig_src/1
  edge_detect/1 -> Inverter/1, Register1/3, dram_munge/4(init), Register6/2, init/1
  enable/1 -> Delay1/1
  Constant1/1 -> Mux2/3
  Constant2/1 -> Mux1/3
  trig_src/1 -> Delay2/1
  valid_src/1 -> Delay3/1
  Constant/1 -> Register1/1
  Register1/1 -> Register6/3
  Logical/1 -> Register1/2
  stopi/1 -> stop/1
