simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 32 of 131)

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv13 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv14 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv15 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv16 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv17 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv18 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv19 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv20 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv21 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv22 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv23 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv24 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out24) -> conv1/1(din)
  debus/2(out23) -> conv2/1(din)
  debus/3(out22) -> conv3/1(din)
  debus/4(out21) -> conv4/1(din)
  debus/5(out20) -> conv5/1(din)
  debus/6(out19) -> conv6/1(din)
  debus/7(out18) -> conv7/1(din)
  debus/8(out17) -> conv8/1(din)
  debus/9(out16) -> conv9/1(din)
  debus/10(out15) -> conv10/1(din)
  debus/11(out14) -> conv11/1(din)
  debus/12(out13) -> conv12/1(din)
  debus/13(out12) -> conv13/1(din)
  debus/14(out11) -> conv14/1(din)
  debus/15(out10) -> conv15/1(din)
  debus/16(out9) -> conv16/1(din)
  debus/17(out8) -> conv17/1(din)
  debus/18(out7) -> conv18/1(din)
  debus/19(out6) -> conv19/1(din)
  debus/20(out5) -> conv20/1(din)
  debus/21(out4) -> conv21/1(din)
  debus/22(out3) -> conv22/1(din)
  debus/23(out2) -> conv23/1(din)
  debus/24(lsb_out1) -> conv24/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv13/1(dout) -> bussify/13(in13)
  conv14/1(dout) -> bussify/14(in14)
  conv15/1(dout) -> bussify/15(in15)
  conv16/1(dout) -> bussify/16(in16)
  conv17/1(dout) -> bussify/17(in17)
  conv18/1(dout) -> bussify/18(in18)
  conv19/1(dout) -> bussify/19(in19)
  conv20/1(dout) -> bussify/20(in20)
  conv21/1(dout) -> bussify/21(in21)
  conv22/1(dout) -> bussify/22(in22)
  conv23/1(dout) -> bussify/23(in23)
  conv24/1(dout) -> bussify/24(in24)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  conv13/2(of) -> of_bussify/13(in13)
  conv14/2(of) -> of_bussify/14(in14)
  conv15/2(of) -> of_bussify/15(in15)
  conv16/2(of) -> of_bussify/16(in16)
  conv17/2(of) -> of_bussify/17(in17)
  conv18/2(of) -> of_bussify/18(in18)
  conv19/2(of) -> of_bussify/19(in19)
  conv20/2(of) -> of_bussify/20(in20)
  conv21/2(of) -> of_bussify/21(in21)
  conv22/2(of) -> of_bussify/22(in22)
  conv23/2(of) -> of_bussify/23(in23)
  conv24/2(of) -> of_bussify/24(in24)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=216  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=216  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=24}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv{1..24} (24 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out24) -> conv1/1
  debus/2(out23) -> conv2/1
  debus/3(out22) -> conv3/1
  debus/4(out21) -> conv4/1
  debus/5(out20) -> conv5/1
  debus/6(out19) -> conv6/1
  debus/7(out18) -> conv7/1
  debus/8(out17) -> conv8/1
  debus/9(out16) -> conv9/1
  debus/10(out15) -> conv10/1
  debus/11(out14) -> conv11/1
  debus/12(out13) -> conv12/1
  debus/13(out12) -> conv13/1
  debus/14(out11) -> conv14/1
  debus/15(out10) -> conv15/1
  debus/16(out9) -> conv16/1
  debus/17(out8) -> conv17/1
  debus/18(out7) -> conv18/1
  debus/19(out6) -> conv19/1
  debus/20(out5) -> conv20/1
  debus/21(out4) -> conv21/1
  debus/22(out3) -> conv22/1
  debus/23(out2) -> conv23/1
  debus/24(lsb_out1) -> conv24/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  conv13/1 -> bussify/13(in13)
  conv14/1 -> bussify/14(in14)
  conv15/1 -> bussify/15(in15)
  conv16/1 -> bussify/16(in16)
  conv17/1 -> bussify/17(in17)
  conv18/1 -> bussify/18(in18)
  conv19/1 -> bussify/19(in19)
  conv20/1 -> bussify/20(in20)
  conv21/1 -> bussify/21(in21)
  conv22/1 -> bussify/22(in22)
  conv23/1 -> bussify/23(in23)
  conv24/1 -> bussify/24(in24)
  bussify/1(bus_out) -> dout/1
