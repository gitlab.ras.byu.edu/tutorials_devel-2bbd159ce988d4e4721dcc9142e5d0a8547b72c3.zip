simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 77 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(in)
  debus/2(out11) -> conv2/1(in)
  debus/3(out10) -> conv3/1(in)
  debus/4(out9) -> conv4/1(in)
  debus/5(out8) -> conv5/1(in)
  debus/6(out7) -> conv6/1(in)
  debus/7(out6) -> conv7/1(in)
  debus/8(out5) -> conv8/1(in)
  debus/9(out4) -> conv9/1(in)
  debus/10(out3) -> conv10/1(in)
  debus/11(out2) -> conv11/1(in)
  debus/12(lsb_out1) -> conv12/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4], outputBinaryPt=[0], outputArithmeticType=[0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4  4  4], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  relational1 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  relational2 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  relational3 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1
  b_debus/1(msb_out3) -> relational1/2
  b_debus/2(out2) -> relational2/2
  b_debus/3(lsb_out1) -> relational3/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  bussify/1(bus_out) -> a!=b/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  scale{1..12} (12 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> scale1/1
  debus/2(out11) -> scale2/1
  debus/3(out10) -> scale3/1
  debus/4(out9) -> scale4/1
  debus/5(out8) -> scale5/1
  debus/6(out7) -> scale6/1
  debus/7(out6) -> scale7/1
  debus/8(out5) -> scale8/1
  debus/9(out4) -> scale9/1
  debus/10(out3) -> scale10/1
  debus/11(out2) -> scale11/1
  debus/12(lsb_out1) -> scale12/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18  18  18  18  18  18], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addsub{1..6} (6 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  dbl_ovrd=off  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[19  19  19  19  19  19], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out6) -> addsub1/1
  b_debus/1(msb_out6) -> addsub1/2
  a_debus/2(out5) -> addsub2/1
  b_debus/2(out5) -> addsub2/2
  a_debus/3(out4) -> addsub3/1
  b_debus/3(out4) -> addsub3/2
  a_debus/4(out3) -> addsub4/1
  b_debus/4(out3) -> addsub4/2
  a_debus/5(out2) -> addsub5/1
  b_debus/5(out2) -> addsub5/2
  a_debus/6(lsb_out1) -> addsub6/1
  b_debus/6(lsb_out1) -> addsub6/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  op_bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[2 2 2 2 2 2], outputBinaryPt=[0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out6) -> join/1(in1)
  split/4(out3) -> join/2(in2)
  split/2(out5) -> join/3(in3)
  split/5(out2) -> join/4(in4)
  split/3(out4) -> join/5(in5)
  split/6(lsb_out1) -> join/6(in6)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/mux ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[0  0  0  0  0  0  0  0  0  0  0  0], outputArithmeticType=[0  0  0  0  0  0  0  0  0  0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[0  0  0  0  0  0  0  0  0  0  0  0], outputArithmeticType=[0  0  0  0  0  0  0  0  0  0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux{0..11} (12 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=12, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out12) -> mux0/1
  expand0/1(msb_out12) -> mux0/2
  expand1/1(msb_out12) -> mux0/3
  sel_expand/2(out11) -> mux1/1
  expand0/2(out11) -> mux1/2
  expand1/2(out11) -> mux1/3
  sel_expand/3(out10) -> mux2/1
  expand0/3(out10) -> mux2/2
  expand1/3(out10) -> mux2/3
  sel_expand/4(out9) -> mux3/1
  expand0/4(out9) -> mux3/2
  expand1/4(out9) -> mux3/3
  sel_expand/5(out8) -> mux4/1
  expand0/5(out8) -> mux4/2
  expand1/5(out8) -> mux4/3
  sel_expand/6(out7) -> mux5/1
  expand0/6(out7) -> mux5/2
  expand1/6(out7) -> mux5/3
  sel_expand/7(out6) -> mux6/1
  expand0/7(out6) -> mux6/2
  expand1/7(out6) -> mux6/3
  sel_expand/8(out5) -> mux7/1
  expand0/8(out5) -> mux7/2
  expand1/8(out5) -> mux7/3
  sel_expand/9(out4) -> mux8/1
  expand0/9(out4) -> mux8/2
  expand1/9(out4) -> mux8/3
  sel_expand/10(out3) -> mux9/1
  expand0/10(out3) -> mux9/2
  expand1/10(out3) -> mux9/3
  sel_expand/11(out2) -> mux10/1
  expand0/11(out2) -> mux10/2
  expand1/11(out2) -> mux10/3
  sel_expand/12(lsb_out1) -> mux11/1
  expand0/12(lsb_out1) -> mux11/2
  expand1/12(lsb_out1) -> mux11/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  mux3/1 -> d_bussify/4(in4)
  mux4/1 -> d_bussify/5(in5)
  mux5/1 -> d_bussify/6(in6)
  mux6/1 -> d_bussify/7(in7)
  mux7/1 -> d_bussify/8(in8)
  mux8/1 -> d_bussify/9(in9)
  mux9/1 -> d_bussify/10(in10)
  mux10/1 -> d_bussify/11(in11)
  mux11/1 -> d_bussify/12(in12)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/shift_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_{0..11} (12 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1, din0_4/1, din0_5/1, din0_6/1, din0_7/1, din0_8/1, din0_9/1, din0_10/1, din0_11/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  din0_2/1 -> bussify/3(in3)
  din0_3/1 -> bussify/4(in4)
  din0_4/1 -> bussify/5(in5)
  din0_5/1 -> bussify/6(in6)
  din0_6/1 -> bussify/7(in7)
  din0_7/1 -> bussify/8(in8)
  din0_8/1 -> bussify/9(in9)
  din0_9/1 -> bussify/10(in10)
  din0_10/1 -> bussify/11(in11)
  din0_11/1 -> bussify/12(in12)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle ==
  ai : Inport
  bi : Inport  Port=2
  sync_in : Inport  Port=3
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=repmat(input_bit_width+coeff_bit_width+1, 1, n_inputs), bin_pt_in=(bin_pt_in+coeff_bit_width-1), cmplx=on, n_bits_out=input_bit_width+1, bin_pt_out=bin_pt_in, quantization=2, overflow=0, csp_latency=conv_latency, of=off, misc=on}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[n_inputs*input_bit_width*2, 1+(n_inputs*input_bit_width*2)], outputBinaryPt=[0 0], outputArithmeticType=[0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[1 108], outputBinaryPt=[0 0], outputArithmeticType=[2 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult  mask(bus_mult){n_bits_a=coeff_bit_width, bin_pt_a=coeff_bit_width-1, type_a=1, cmplx_a=on, n_bits_b=[18 18 18], bin_pt_b=bin_pt_in, type_b=1, cmplx_b=on, misc=on, floating_point=off, float_type=single, input_vec_a=1, input_vec_b=1, frac_width=24, exp_width=8, n_bits_out=input_bit_width+coeff_bit_width+1, bin_pt_out=(bin_pt_in+coeff_bit_width-1), type_out=1, quantization=0, overflow=0, mult_latency=mult_latency, add_latency=add_latency, conv_latency=0, max_fanout=max_fanout, fan_latency=3, multiplier_implementation=behavioral HDL, pipeline_cmult_en=off, pipeline_latency=0}
      mask prompts: n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; cmplx_a "a input complex"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx_b "b input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; input_vec_a "a input vector in bus"; input_vec_b "b input vector in bus"; frac_width "fraction width"; exp_width "exponent width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; mult_latency "multiplier latency"; add_latency "adder latency"; conv_latency "convert latency"; max_fanout "limit fanout to ?"; fan_latency "fanout register latency"; multiplier_implementation "multiplier implementation"; pipeline_cmult_en "pipeline complex mult"; pipeline_latency "pipeline latency"
      mask help: Multiply components of two busses
      mask init:
      | bus_mult_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'cmplx_a', cmplx_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'cmplx_b', cmplx_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'type_out', type_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'input_vec_a', input_vec_a, ...
      |     'input_vec_b', input_vec_b, ...
      |     'frac_width', frac_width, ...         
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'max_fanout', max_fanout, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'misc', misc);
  coeff_gen : Subsystem  AncestorBlock=casper_library_ffts_twiddle_coeff_gen/coeff_gen  mask(coeff_gen){FFTSize=FFTSize, Coeffs=[0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 96 97 98 99 100 101 102 103 104 105 106 107 108 109 110 111 112 113 114 115 116 117 118 119 120 121 122 123 124 125 126 1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, coeff_bit_width=coeff_bit_width, StepPeriod=StepPeriod, async=off, misc=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, bram_latency=bram_latency, mult_latency=mult_latency, add_latency=add_latency, conv_latency=conv_latency, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=cal_bits, n_bits_rotation=n_bits_rotation, quantization=Round  (unbiased: Even Values)}
      mask prompts: FFTSize "fft size (2^?)"; Coeffs "Coefficients"; coeff_bit_width "Coefficient Bit Width:"; StepPeriod "Step Period: (2^?)"; async "asynchronous operation"; misc "misc port"; floating_point "floating point"; exp_width "exponential width"; frac_width "fractional width"; bram_latency "BRAM latency"; mult_latency "Multiplier latency"; add_latency "Adder latency"; conv_latency "Convert latency"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Rotation vector resolution"; quantization "Quantization strategy"
      mask help: Generates a sequence of complex coefficients for use in generating twiddle factors for FFTs.
      mask init:
      | coeff_gen_init(gcb, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...       
      |    'StepPeriod', StepPeriod, ...
      |    'async', async, ...
      |    'misc', misc, ...
      |    'bram_latency', bram_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'add_latency', add_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'quantization', quantization);
  ao : Outport
  bwo : Outport  Port=2
  sync_out : Outport  Port=3
  wires:
  bi/1 -> bus_create/1(in1)
  sync_in/1 -> bus_create/2(in2), coeff_gen/1(rst)
  ai/1 -> bus_create/3(in3)
  bus_create/1(bus_out) -> coeff_gen/2(misci)
  coeff_gen/2(misco) -> bus_expand/1(bus_in)
  coeff_gen/1(w) -> bus_mult/1(a)
  bus_expand/2(lsb_out1) -> bus_mult/3(misci)
  bus_expand/1(msb_out2) -> bus_mult/2(b)
  bus_mult/1(a*b) -> bus_convert/1(din)
  bus_mult/2(misco) -> bus_convert/2(misci)
  bus_convert/1(dout) -> bwo/1
  bus_convert/2(misco) -> bus_expand1/1(bus_in)
  bus_expand1/1(msb_out2) -> sync_out/1
  bus_expand1/2(lsb_out1) -> ao/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay0/din_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay0/dout_compress ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay1/din_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/delay1/dout_compress ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
