simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 3 of 131)

== system snap_tut_corr/decat2 ==
  In1 : Inport
  Reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Slice15 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=8  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice16 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=16  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice17 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=24  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice9 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Out1 : Outport
  Out2 : Outport  Port=2
  Out3 : Outport  Port=3
  Out4 : Outport  Port=4
  wires:
  Reinterpret4/1 -> Out4/1
  Reinterpret3/1 -> Out3/1
  Reinterpret1/1 -> Out2/1
  Reinterpret2/1 -> Out1/1
  Slice9/1 -> Reinterpret4/1
  Slice15/1 -> Reinterpret3/1
  Slice16/1 -> Reinterpret1/1
  Slice17/1 -> Reinterpret2/1
  In1/1 -> Slice15/1, Slice9/1, Slice16/1, Slice17/1

== system snap_tut_corr/dir_x0 ==
  new_acc : Inport
  a : Inport  Port=2
  b : Inport  Port=3
  c : Inport  Port=4
  aa : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  ab : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  ac : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  bb : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  bc : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  cc : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  a/1 -> aa/2(c+di), aa/1(a+bi), ab/1(a+bi), ac/1(a+bi)
  new_acc/1 -> bb/3(new_acc), ab/3(new_acc), cc/3(new_acc), bc/3(new_acc), ac/3(new_acc), aa/3(new_acc)
  c/1 -> ac/2(c+di), bc/2(c+di), cc/1(a+bi), cc/2(c+di)
  b/1 -> ab/2(c+di), bb/2(c+di), bb/1(a+bi), bc/1(a+bi)

== system snap_tut_corr/dir_x1 ==
  new_acc : Inport
  a : Inport  Port=2
  b : Inport  Port=3
  c : Inport  Port=4
  aa : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  ab : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  ac : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  bb : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  bc : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of Channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  cc : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  a/1 -> aa/2(c+di), aa/1(a+bi), ab/1(a+bi), ac/1(a+bi)
  new_acc/1 -> bb/3(new_acc), ab/3(new_acc), cc/3(new_acc), bc/3(new_acc), ac/3(new_acc), aa/3(new_acc)
  c/1 -> ac/2(c+di), bc/2(c+di), cc/1(a+bi), cc/2(c+di)
  b/1 -> ab/2(c+di), bb/2(c+di), bb/1(a+bi), bc/1(a+bi)

== system snap_tut_corr/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/edge_detect1 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/edge_detect3 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/fft_shift ==
  sim_1 : Inport
  convert1_1 : DataTypeConversion  OutDataTypeStr=fixdt('ufix32_En0')
  convert2_1 : DataTypeConversion  OutDataTypeStr=fixdt('ufix32_En0')  ConvertRealWorld=Stored Integer (SI)
  gain_1 : Gain
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice_reg : xbsIndex_r4/Slice  nbits=32  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  snap_tut_corr_fft_shift_user_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  in_reg : Outport
  wires:
  snap_tut_corr_fft_shift_user_data_out/1 -> io_delay/1
  sim_1/1 -> convert1_1/1
  convert1_1/1 -> convert2_1/1
  convert2_1/1 -> gain_1/1
  gain_1/1 -> snap_tut_corr_fft_shift_user_data_out/1
  io_delay/1 -> slice_reg/1
  slice_reg/1 -> reint1/1
  reint1/1 -> in_reg/1

== system snap_tut_corr/fft_wideband_real ==
  sync : Inport
  shift : Inport  Port=2
  in00 : Inport  Port=3
  in01 : Inport  Port=4
  in02 : Inport  Port=5
  in03 : Inport  Port=6
  in10 : Inport  Port=7
  in11 : Inport  Port=8
  in12 : Inport  Port=9
  in13 : Inport  Port=10
  in20 : Inport  Port=11
  in21 : Inport  Port=12
  in22 : Inport  Port=13
  in23 : Inport  Port=14
  del_4x_pol0 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol1 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol10 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol11 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol2 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol3 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol4 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol5 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol6 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol7 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol8 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_4x_pol9 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct1 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct10 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct2 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct5 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct6 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_direct9 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  del_sync_4x : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  fft_biplex_real_4x : Subsystem  Tag=casper:fft_biplex_real_4x  AncestorBlock=casper_library_ffts/fft_biplex_real_4x  mask(fft_biplex_real_4x){n_inputs=3, FFTSize=9, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bit_limit=7, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, mult_spec=[2 2 2 2 2 2 2 2 2], bitgrowth=off, max_bits=19, hardcode_shifts=off, shift_schedule=[1 1 1 1 1 1 1 1 1], dsp48_adders=off}
      mask prompts: n_inputs "Number simultaneous inputs (4*?)"; FFTSize "Size of FFT: (2^? pts)"; input_bit_width "Input bit width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bit_limit "Number bits above which to implement stage's delays in BRAM (2^? bits)"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; mult_spec "Multiplier impl. (0=core, 1=embedded, 2=behavioural) (left=1st stage, or just one value)"; bitgrowth "Bitgrowth instead of shifting"; max_bits "Max bits to grow to"; hardcode_shifts "Hardcode shift schedule"; shift_schedule "Shift schedule"; dsp48_adders "DSP48 adders in butterfly"
      mask help: A real-sampled biplex FFT, with output demuxed by 4.
      mask init:
      | fft_biplex_real_4x_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...    
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bit_limit', delays_bit_limit, ... 
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...   
      |     'mult_spec', mult_spec, ...
      |     'bitgrowth', bitgrowth, ...
      |     'max_bits', max_bits, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'shift_schedule', shift_schedule, ...
      |     'dsp48_adders', dsp48_adders);
  fft_direct : Subsystem  AncestorBlock=casper_library_ffts/fft_direct  mask(fft_direct){n_streams=3, FFTSize=2, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, map_tail=on, LargerFFTSize=11, StartStage=10, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=8, mult_spec=[2 2], bitgrowth=off, max_bits=19, hardcode_shifts=off, shift_schedule=[1 1], dsp48_adders=off}
      mask prompts: n_streams "Number simultaneous streams"; FFTSize "Size of FFT: (2^? pts)"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; map_tail "Map Tail of Larger FFT"; LargerFFTSize "Size of Larger FFT (2^?)"; StartStage "Start Stage of Map Tail"; async "Asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add interface pipeline latency"; mult_pipe_latency "Cmult pipeline latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; mult_spec "Multiplier impl. (0=core, 1=embedded, 2=behavioural) (left=1st stage, or just one value)"; bitgrowth "Bit growth instead of shifting"; max_bits "Max bits to growth to"; hardcode_shifts "Hardcode shift schedule"; shift_schedule "Shift schedule"; dsp48_adders "DSP48 adders in butterfly"
      mask help: FFT internal block. Implements an N-point FFT as the classic butterfly structure, with N inputs and N outputs.
      mask init:
      | fft_direct_init(gcb, ...
      |     'n_streams', n_streams, ...
      |     'FFTSize', FFTSize, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'map_tail', map_tail, ...
      |     'LargerFFTSize', LargerFFTSize, ...
      |     'StartStage', StartStage, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...          
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'coeff_generation', coeff_generation, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...      
      |     'cal_bits', cal_bits, ...
      |     'n_bits_rotation', n_bits_rotation, ...
      |     'max_fanout', max_fanout, ...
      |     'mult_spec', mult_spec, ...
      |     'bitgrowth', bitgrowth, ...
      |     'max_bits', max_bits, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'shift_schedule', shift_schedule, ...
      |     'dsp48_adders', dsp48_adders);
  fft_direct_sync_delay : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  fft_unscrambler : Subsystem  AncestorBlock=casper_library_ffts/fft_unscrambler  mask(fft_unscrambler){n_streams=3, FFTSize=10, n_inputs=1, n_bits_in=18, bram_latency=3, coeffs_bit_limit=7, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_streams "Number of simultaneous streams"; FFTSize "Size of FFT: (2^?)"; n_inputs "Number of simultaneous inputs: (2^?)"; n_bits_in "Input bit width"; bram_latency "BRAM Latency"; coeffs_bit_limit "Number bits above which to store map coefficients in BRAM (2^? bits)"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"
      mask init:
      | fft_unscrambler_init(gcb, ...
      |     'n_streams', n_streams, ...
      |     'FFTSize',FFTSize, ... 
      |     'n_inputs', n_inputs, ...
      |     'n_bits_in', n_bits_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'bram_latency', bram_latency, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'async', async);
  in_del_4x_pol0 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol1 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol10 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol11 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol2 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol3 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol4 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol5 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol6 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol7 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol8 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_4x_pol9 : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  in_del_sync_4x : Subsystem  AncestorBlock=casper_library_delays/pipeline  mask(pipeline){csp_latency=0}
      mask prompts: csp_latency "Latency"
      mask help: An explicitly laid-out delay line to avoid mapping to SRL16s for use in pipelining to help achieve timing closure.
      mask init:
      | pipeline_init(gcb,'latency',csp_latency);
  of_or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  slice : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=9  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  t{0..5} (6 alike) : Terminator
  sync_out : Outport
  out00 : Outport  Port=2
  out01 : Outport  Port=3
  out10 : Outport  Port=4
  out11 : Outport  Port=5
  out20 : Outport  Port=6
  out21 : Outport  Port=7
  of : Outport  Port=8
  wires:
  sync/1 -> in_del_sync_4x/1(d)
  shift/1 -> fft_biplex_real_4x/2(shift), slice/1
  in_del_sync_4x/1(q) -> fft_biplex_real_4x/1(sync)
  fft_biplex_real_4x/1(sync_out) -> del_sync_4x/1(d)
  del_sync_4x/1(q) -> fft_direct/1(sync)
  fft_direct/4(out02) -> t0/1
  fft_direct/5(out03) -> t1/1
  fft_direct/8(out12) -> t2/1
  fft_direct/9(out13) -> t3/1
  fft_direct/12(out22) -> t4/1
  fft_direct/13(out23) -> t5/1
  fft_direct/1(sync_out) -> fft_direct_sync_delay/1(d)
  fft_direct_sync_delay/1(q) -> fft_unscrambler/1(sync)
  fft_unscrambler/1(sync_out) -> sync_out/1
  fft_direct/2(out00) -> del_direct1/1(d)
  del_direct1/1(q) -> fft_unscrambler/2(in00)
  fft_unscrambler/2(out00) -> out00/1
  fft_direct/3(out01) -> del_direct2/1(d)
  del_direct2/1(q) -> fft_unscrambler/3(in01)
  fft_unscrambler/3(out01) -> out01/1
  fft_direct/6(out10) -> del_direct5/1(d)
  del_direct5/1(q) -> fft_unscrambler/4(in10)
  fft_unscrambler/4(out10) -> out10/1
  fft_direct/7(out11) -> del_direct6/1(d)
  del_direct6/1(q) -> fft_unscrambler/5(in11)
  fft_unscrambler/5(out11) -> out11/1
  fft_direct/10(out20) -> del_direct9/1(d)
  del_direct9/1(q) -> fft_unscrambler/6(in20)
  fft_unscrambler/6(out20) -> out20/1
  fft_direct/11(out21) -> del_direct10/1(d)
  del_direct10/1(q) -> fft_unscrambler/7(in21)
  fft_unscrambler/7(out21) -> out21/1
  slice/1 -> fft_direct/2(shift)
  fft_biplex_real_4x/14(of) -> of_or/2
  fft_direct/14(of) -> of_or/1
  of_or/1 -> of/1
  in00/1 -> in_del_4x_pol0/1(d)
  in_del_4x_pol0/1(q) -> fft_biplex_real_4x/3(pol0_in)
  fft_biplex_real_4x/2(pol0_out) -> del_4x_pol0/1(d)
  del_4x_pol0/1(q) -> fft_direct/3(in00)
  in01/1 -> in_del_4x_pol1/1(d)
  in_del_4x_pol1/1(q) -> fft_biplex_real_4x/4(pol1_in)
  fft_biplex_real_4x/3(pol1_out) -> del_4x_pol1/1(d)
  del_4x_pol1/1(q) -> fft_direct/4(in01)
  in02/1 -> in_del_4x_pol2/1(d)
  in_del_4x_pol2/1(q) -> fft_biplex_real_4x/5(pol2_in)
  fft_biplex_real_4x/4(pol2_out) -> del_4x_pol2/1(d)
  del_4x_pol2/1(q) -> fft_direct/5(in02)
  in03/1 -> in_del_4x_pol3/1(d)
  in_del_4x_pol3/1(q) -> fft_biplex_real_4x/6(pol3_in)
  fft_biplex_real_4x/5(pol3_out) -> del_4x_pol3/1(d)
  del_4x_pol3/1(q) -> fft_direct/6(in03)
  in10/1 -> in_del_4x_pol4/1(d)
  in_del_4x_pol4/1(q) -> fft_biplex_real_4x/7(pol4_in)
  fft_biplex_real_4x/6(pol4_out) -> del_4x_pol4/1(d)
  del_4x_pol4/1(q) -> fft_direct/7(in10)
  in11/1 -> in_del_4x_pol5/1(d)
  in_del_4x_pol5/1(q) -> fft_biplex_real_4x/8(pol5_in)
  fft_biplex_real_4x/7(pol5_out) -> del_4x_pol5/1(d)
  del_4x_pol5/1(q) -> fft_direct/8(in11)
  in12/1 -> in_del_4x_pol6/1(d)
  in_del_4x_pol6/1(q) -> fft_biplex_real_4x/9(pol6_in)
  fft_biplex_real_4x/8(pol6_out) -> del_4x_pol6/1(d)
  del_4x_pol6/1(q) -> fft_direct/9(in12)
  in13/1 -> in_del_4x_pol7/1(d)
  in_del_4x_pol7/1(q) -> fft_biplex_real_4x/10(pol7_in)
  fft_biplex_real_4x/9(pol7_out) -> del_4x_pol7/1(d)
  del_4x_pol7/1(q) -> fft_direct/10(in13)
  in20/1 -> in_del_4x_pol8/1(d)
  in_del_4x_pol8/1(q) -> fft_biplex_real_4x/11(pol8_in)
  fft_biplex_real_4x/10(pol8_out) -> del_4x_pol8/1(d)
  del_4x_pol8/1(q) -> fft_direct/11(in20)
  in21/1 -> in_del_4x_pol9/1(d)
  in_del_4x_pol9/1(q) -> fft_biplex_real_4x/12(pol9_in)
  fft_biplex_real_4x/11(pol9_out) -> del_4x_pol9/1(d)
  del_4x_pol9/1(q) -> fft_direct/12(in21)
  in22/1 -> in_del_4x_pol10/1(d)
  in_del_4x_pol10/1(q) -> fft_biplex_real_4x/13(pol10_in)
  fft_biplex_real_4x/12(pol10_out) -> del_4x_pol10/1(d)
  del_4x_pol10/1(q) -> fft_direct/13(in22)
  in23/1 -> in_del_4x_pol11/1(d)
  in_del_4x_pol11/1(q) -> fft_biplex_real_4x/14(pol11_in)
  fft_biplex_real_4x/13(pol11_out) -> del_4x_pol11/1(d)
  del_4x_pol11/1(q) -> fft_direct/14(in23)

== system snap_tut_corr/negedge_delay1 ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len-2  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Logical : xbsIndex_r4/Logical  logical_function=OR  inputs=3  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  Relational5 : xbsIndex_r4/Relational  mode=a<=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  negedge : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Falling, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1  1  1  1  1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1 -1 -1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  out : Outport
  wires:
  Delay/1 -> Logical/2
  Logical/1 -> out/1
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Logical/3, Counter3/2
  in/1 -> Logical/1, Delay/1, negedge/1(in)
  negedge/1(out) -> Counter3/1

== system snap_tut_corr/pfb_fir_generic ==
  sync : Inport
  pol0_in0 : Inport  Port=2
  pol0_in1 : Inport  Port=3
  pol0_in2 : Inport  Port=4
  pol0_in3 : Inport  Port=5
  pol1_in0 : Inport  Port=6
  pol1_in1 : Inport  Port=7
  pol1_in2 : Inport  Port=8
  pol1_in3 : Inport  Port=9
  pol2_in0 : Inport  Port=10
  pol2_in1 : Inport  Port=11
  pol2_in2 : Inport  Port=12
  pol2_in3 : Inport  Port=13
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[28 28 28 28 28 28 28 28 28 28 28 28], bin_pt_in=25, cmplx=off, n_bits_out=18, bin_pt_out=17, quantization=2, overflow=0, csp_latency=1, of=off, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=12, outputWidth=18, outputBinaryPt=17, outputArithmeticType=1, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale  mask(bus_scale){n_bits_in=[28 28 28 28 28 28 28 28 28 28 28 28], bin_pt_in=24, type_in=1, cmplx=off, scale_factor=-1, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; type_in "input types"; cmplx "input complex"; scale_factor "scale factor (2^?)"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_scale_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'type_in', type_in, ...
      |     'cmplx', cmplx, ...
      |     'scale_factor', scale_factor, ...
      |     'misc', misc);
  coeff_munge : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=16, div_size=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], order=[12 12 12 13 13 13 14 14 14 15 15 15 8 8 8 9 9 9 10 10 10 11 11 11 4 4 4 5 5 5 6 6 6 7 7 7 0 0 0 1 1 1 2 2 2 3 3 3], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  pfb_fir_coeff_gen : Subsystem  AncestorBlock=casper_library_pfbs/pfb_fir_coeff_gen  mask(pfb_fir_coeff_gen){pfb_size=11, n_taps=4, n_bits_coeff=18, WindowType=hamming, n_inputs=2, fwidth=1, async=off, bram_latency=1, fan_latency=1, add_latency=2, bram_optimization=Area}
      mask prompts: pfb_size "Size of PFB: (2^? pnts)"; n_taps "Total Number of Taps:"; n_bits_coeff "Bitwidth of Coefficients:"; WindowType "Windowing Function:"; n_inputs "Number of Simultaneous Inputs: (2^?)"; fwidth "Bin Width (normal=1)"; async "Asynchronous operation"; bram_latency "BRAM Latency"; fan_latency "Fanout latency"; add_latency "Add latency"; bram_optimization "BRAM optimization"
      mask init:
      | pfb_fir_coeff_gen_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'pfb_size', pfb_size, ...
      |     'n_taps', n_taps, ...
      |     'n_bits_coeff', n_bits_coeff, ...
      |     'WindowType', WindowType, ...
      |     'fwidth', fwidth, ...
      |     'async', async, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'add_latency', add_latency, ...
      |     'bram_optimization', bram_optimization);
  pfb_fir_taps : Subsystem  AncestorBlock=casper_library_pfbs/pfb_fir_taps  mask(pfb_fir_taps){n_streams=3, n_inputs=2, pfb_size=11, n_taps=4, n_bits_data=8, n_bits_coeff=18, bin_pt_coeff=17, complex=off, async=off, floating_point=off, float_type=single, frac_width=24, exp_width=8, mult_latency=3, add_latency=2, bram_latency=1, fan_latency=1, fixed_float_latency=0, multiplier_implementation=behavioral HDL, bram_optimization=Area}
      mask prompts: n_streams "Number simultaneous streams"; n_inputs "Number simultaneous inputs per stream (2^?)"; pfb_size "PFB size (2^? pnts)"; n_taps "Number of taps"; n_bits_data "Data bit width in"; n_bits_coeff "Coefficient bit width"; bin_pt_coeff "Coefficient binary point"; complex "Complex input data"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; frac_width "fraction width"; exp_width "exponent width"; mult_latency "Multiplier latency"; add_latency "Adder latency"; bram_latency "BRAM latency"; fan_latency "Fanout latency"; fixed_float_latency "fixed to float latency"; multiplier_implementation "Multiplier implementation"; bram_optimization "BRAM optimization"
      mask init:
      | pfb_fir_taps_init(gcb, ...
      |     'n_streams', n_streams, ...
      |     'n_inputs', n_inputs, ...
      |     'pfb_size', pfb_size, ...
      |     'n_taps', n_taps, ...
      |     'n_bits_data', n_bits_data, ...
      |     'n_bits_coeff', n_bits_coeff, ...
      |     'bin_pt_coeff', bin_pt_coeff, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...   
      |     'fixed_float_latency', fixed_float_latency, ...
      |     'complex', complex, ...
      |     'async', async, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'bram_optimization', bram_optimization);
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=conv_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  pol0_out0 : Outport  Port=2
  pol0_out1 : Outport  Port=3
  pol0_out2 : Outport  Port=4
  pol0_out3 : Outport  Port=5
  pol1_out0 : Outport  Port=6
  pol1_out1 : Outport  Port=7
  pol1_out2 : Outport  Port=8
  pol1_out3 : Outport  Port=9
  pol2_out0 : Outport  Port=10
  pol2_out1 : Outport  Port=11
  pol2_out2 : Outport  Port=12
  pol2_out3 : Outport  Port=13
  wires:
  pol0_in0/1 -> bus_create/1(in1)
  bus_expand/1(msb_out12) -> pol0_out0/1
  pol0_in1/1 -> bus_create/4(in4)
  bus_expand/4(out9) -> pol0_out1/1
  pol0_in2/1 -> bus_create/7(in7)
  bus_expand/7(out6) -> pol0_out2/1
  pol0_in3/1 -> bus_create/10(in10)
  bus_expand/10(out3) -> pol0_out3/1
  pol1_in0/1 -> bus_create/2(in2)
  bus_expand/2(out11) -> pol1_out0/1
  pol1_in1/1 -> bus_create/5(in5)
  bus_expand/5(out8) -> pol1_out1/1
  pol1_in2/1 -> bus_create/8(in8)
  bus_expand/8(out5) -> pol1_out2/1
  pol1_in3/1 -> bus_create/11(in11)
  bus_expand/11(out2) -> pol1_out3/1
  pol2_in0/1 -> bus_create/3(in3)
  bus_expand/3(out10) -> pol2_out0/1
  pol2_in1/1 -> bus_create/6(in6)
  bus_expand/6(out7) -> pol2_out1/1
  pol2_in2/1 -> bus_create/9(in9)
  bus_expand/9(out4) -> pol2_out2/1
  pol2_in3/1 -> bus_create/12(in12)
  bus_expand/12(lsb_out1) -> pol2_out3/1
  bus_create/1(bus_out) -> pfb_fir_coeff_gen/2(din)
  pfb_fir_coeff_gen/3(coeffs) -> coeff_munge/1(din)
  pfb_fir_coeff_gen/2(dout) -> pfb_fir_taps/2(din)
  coeff_munge/1(dout) -> pfb_fir_taps/3(coeffs)
  pfb_fir_taps/2(dout) -> bus_scale/1(din)
  bus_scale/1(dout) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  sync/1 -> pfb_fir_coeff_gen/1(sync)
  pfb_fir_coeff_gen/1(sync_out) -> pfb_fir_taps/1(sync)
  pfb_fir_taps/1(sync_out) -> sync_delay/1
  sync_delay/1 -> sync_out/1

== system snap_tut_corr/pulse_ext2 ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Rising, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1  1  1  1  1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1 -1 -1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> edge_detect/1(in)
  edge_detect/1(out) -> Counter3/1
