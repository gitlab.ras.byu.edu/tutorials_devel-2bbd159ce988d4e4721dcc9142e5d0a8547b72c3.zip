simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 111 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult ==
  a : Inport
  b : Inport  Port=2
  misci : Inport  Port=3
  a*b_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dmisc : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=mult_latency+add_latency+conv_latency+fan_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  mult1 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult2 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult3 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  repa : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=2, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  repb : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=2, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  a*b : Outport
  misco : Outport  Port=2
  wires:
  a/1 -> repa/1(in)
  b/1 -> repb/1(in)
  repa/1(out) -> a_debus/1(bus_in)
  repb/1(out) -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> mult1/1(a), mult2/1(a), mult3/1(a)
  b_debus/1(msb_out3) -> mult1/2(b)
  b_debus/2(out2) -> mult2/2(b)
  b_debus/3(lsb_out1) -> mult3/2(b)
  misci/1 -> dmisc/1
  mult1/1(ab) -> a*b_bussify/1(in1)
  mult2/1(ab) -> a*b_bussify/2(in2)
  mult3/1(ab) -> a*b_bussify/3(in3)
  a*b_bussify/1(bus_out) -> a*b/1
  dmisc/1 -> misco/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/coeff_gen ==
  rst : Inport
  misci : Inport  Port=2
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Slice : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  bit_reverse : Subsystem  AncestorBlock=casper_library_misc/bit_reverse  mask(bit_reverse){n_bits=8}
      mask prompts: n_bits "Number of Bits"
      mask help: Reverses the bit order of the input. Input must be unsigned with binary point at position 0. Costs nothing in hardware.
      mask init:
      | bit_reverse_init(gcb,'n_bits', n_bits);
  cosin : Subsystem  Tag=casper:cosin  AncestorBlock=casper_library_downconverter/cosin  mask(cosin){output0=cos, output1=-sin, indep_theta=off, phase=0, fraction=1, table_bits=8, n_bits=18, bin_pt=17, floating_point=off, float_type=single, exp_width=8, frac_width=24, store=1, pack=on, bram=BRAM, misc=on, bram_latency=3, add_latency=1, mux_latency=2, neg_latency=2, conv_latency=1}
      mask prompts: output0 "first output function"; output1 "second output function"; indep_theta "Independent theta values"; phase "initial phase offset (?*(2*pi))"; fraction "fraction of cycle period to output (1/2^?)"; table_bits "samples in cycle period fraction to output (2^?)"; n_bits "bit width"; bin_pt "binary point"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; store "fraction of cycle period to store (1/2^?)"; pack "pack lookup values in same output word"; bram "BRAM implementation"; misc "Miscellaneous port"; bram_latency "bram latency"; add_latency "large adder latency"; mux_latency "mux latency"; neg_latency "negate latency"; conv_latency "convert latency"
      mask init:
      | cosin_init(gcb, ...
      |     'output0', output0, ...    
      |     'output1', output1, ...
      |     'indep_theta', indep_theta, ...
      |     'phase', phase, ...
      |     'fraction', fraction, ...
      |     'table_bits', table_bits, ...  
      |     'n_bits', n_bits, ...      
      |     'bin_pt', bin_pt, ...    
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...         
      |     'bram_latency', bram_latency, ...
      |     'add_latency', add_latency, ...
      |     'mux_latency', mux_latency, ...
      |     'neg_latency', neg_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'store', store, ...
      |     'pack', pack, ...
      |     'bram', bram, ...
      |     'misc', misc);
  ri_to_c : casper_library_misc/ri_to_c
  w : Outport
  misco : Outport  Port=2
  wires:
  ri_to_c/1 -> w/1
  rst/1 -> Counter/1
  Counter/1 -> Slice/1
  Slice/1 -> bit_reverse/1(in)
  bit_reverse/1(out) -> cosin/1(theta)
  cosin/1(cos) -> ri_to_c/1
  cosin/2(-sin) -> ri_to_c/2
  misci/1 -> cosin/2(misci)
  cosin/3(misco) -> misco/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult1/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult1/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult1/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult1/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult1/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult2/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult2/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult2/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult2/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult2/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult3/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult3/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult3/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult3/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult3/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult4/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult4/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult4/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult4/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult4/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult5/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult5/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult5/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult5/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult5/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult6/a_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult6/a_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult6/b_expand ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult6/b_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/mult6/ri_to_c ==
  re : Inport
  im : Inport  Port=2
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c : Outport
  wires:
  force_re/1 -> concat/1
  force_im/1 -> concat/2
  re/1 -> force_re/1
  concat/1 -> c/1
  im/1 -> force_im/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/repa/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult/repb/bussify ==
  in1 : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> bus_out/1
