simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 22 of 131)

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree ==
  d0 : Inport
  d1 : Inport  Port=2
  d2 : Inport  Port=3
  d3 : Inport  Port=4
  add_tree0 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree1 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree10 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree11 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree2 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree3 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree4 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree5 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree6 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree7 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree8 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  add_tree9 : Subsystem  AncestorBlock=casper_library_misc/adder_tree  mask(adder_tree){n_inputs=4, csp_latency=2, adder_imp=Behavioral, first_stage_hdl=on, floating_point=off, float_type=single, frac_width=0, exp_width=0}
      mask prompts: n_inputs "Number of Inputs"; csp_latency "Add Latency"; adder_imp "Adder implementation"; first_stage_hdl "Use behavioural HDL for first stage of adders"; floating_point "floating point"; float_type "float type"; frac_width "fraction length"; exp_width "exponent length"
      mask help: Sums all inputs using a tree of adds and delays. Number of inputs: The number of inputs to the block to be summed Add latency: The number of clock cycles to perform one addition (affects timing).. Adder implementation: choice of fabric or DSP48E core, or behavioral HDL Use behavioural HDL for first stage of adders: Causes the first stage of adders to be absorbed into DSP blocks if multipliers precede them (Virtex 5). Overrides Adder implementation
      mask init:
      | adder_tree_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'csp_latency', csp_latency, ...
      |     'adder_imp', adder_imp, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...     
      |     'first_stage_hdl', first_stage_hdl);
  constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[26 26 26 26 26 26 26 26 26 26 26 26], outputBinaryPt=[24 24 24 24 24 24 24 24 24 24 24 24], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[26 26 26 26 26 26 26 26 26 26 26 26], outputBinaryPt=[24 24 24 24 24 24 24 24 24 24 24 24], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand2 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[26 26 26 26 26 26 26 26 26 26 26 26], outputBinaryPt=[24 24 24 24 24 24 24 24 24 24 24 24], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand3 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[26 26 26 26 26 26 26 26 26 26 26 26], outputBinaryPt=[24 24 24 24 24 24 24 24 24 24 24 24], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  d2/1 -> expand2/1(bus_in)
  d3/1 -> expand3/1(bus_in)
  constant/1 -> add_tree0/1(sync), add_tree1/1(sync), add_tree2/1(sync), add_tree3/1(sync), add_tree4/1(sync), add_tree5/1(sync), add_tree6/1(sync), add_tree7/1(sync), add_tree8/1(sync), add_tree9/1(sync), add_tree10/1(sync), add_tree11/1(sync)
  expand0/1(msb_out12) -> add_tree0/2(din1)
  expand1/1(msb_out12) -> add_tree0/3(din2)
  expand2/1(msb_out12) -> add_tree0/4(din3)
  expand3/1(msb_out12) -> add_tree0/5(din4)
  expand0/2(out11) -> add_tree1/2(din1)
  expand1/2(out11) -> add_tree1/3(din2)
  expand2/2(out11) -> add_tree1/4(din3)
  expand3/2(out11) -> add_tree1/5(din4)
  expand0/3(out10) -> add_tree2/2(din1)
  expand1/3(out10) -> add_tree2/3(din2)
  expand2/3(out10) -> add_tree2/4(din3)
  expand3/3(out10) -> add_tree2/5(din4)
  expand0/4(out9) -> add_tree3/2(din1)
  expand1/4(out9) -> add_tree3/3(din2)
  expand2/4(out9) -> add_tree3/4(din3)
  expand3/4(out9) -> add_tree3/5(din4)
  expand0/5(out8) -> add_tree4/2(din1)
  expand1/5(out8) -> add_tree4/3(din2)
  expand2/5(out8) -> add_tree4/4(din3)
  expand3/5(out8) -> add_tree4/5(din4)
  expand0/6(out7) -> add_tree5/2(din1)
  expand1/6(out7) -> add_tree5/3(din2)
  expand2/6(out7) -> add_tree5/4(din3)
  expand3/6(out7) -> add_tree5/5(din4)
  expand0/7(out6) -> add_tree6/2(din1)
  expand1/7(out6) -> add_tree6/3(din2)
  expand2/7(out6) -> add_tree6/4(din3)
  expand3/7(out6) -> add_tree6/5(din4)
  expand0/8(out5) -> add_tree7/2(din1)
  expand1/8(out5) -> add_tree7/3(din2)
  expand2/8(out5) -> add_tree7/4(din3)
  expand3/8(out5) -> add_tree7/5(din4)
  expand0/9(out4) -> add_tree8/2(din1)
  expand1/9(out4) -> add_tree8/3(din2)
  expand2/9(out4) -> add_tree8/4(din3)
  expand3/9(out4) -> add_tree8/5(din4)
  expand0/10(out3) -> add_tree9/2(din1)
  expand1/10(out3) -> add_tree9/3(din2)
  expand2/10(out3) -> add_tree9/4(din3)
  expand3/10(out3) -> add_tree9/5(din4)
  expand0/11(out2) -> add_tree10/2(din1)
  expand1/11(out2) -> add_tree10/3(din2)
  expand2/11(out2) -> add_tree10/4(din3)
  expand3/11(out2) -> add_tree10/5(din4)
  expand0/12(lsb_out1) -> add_tree11/2(din1)
  expand1/12(lsb_out1) -> add_tree11/3(din2)
  expand2/12(lsb_out1) -> add_tree11/4(din3)
  expand3/12(lsb_out1) -> add_tree11/5(din4)
  add_tree0/2(dout) -> d_bussify/1(in1)
  add_tree1/2(dout) -> d_bussify/2(in2)
  add_tree2/2(dout) -> d_bussify/3(in3)
  add_tree3/2(dout) -> d_bussify/4(in4)
  add_tree4/2(dout) -> d_bussify/5(in5)
  add_tree5/2(dout) -> d_bussify/6(in6)
  add_tree6/2(dout) -> d_bussify/7(in7)
  add_tree7/2(dout) -> d_bussify/8(in8)
  add_tree8/2(dout) -> d_bussify/9(in9)
  add_tree9/2(dout) -> d_bussify/10(in10)
  add_tree10/2(dout) -> d_bussify/11(in11)
  add_tree11/2(dout) -> d_bussify/12(in12)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_mult ==
  a : Inport
  b : Inport  Port=2
  a*b_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=48}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8], outputBinaryPt=[7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7 7], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mult{1..48} (48 alike) : xbsIndex_r4/Mult  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=26  bin_pt=24  quantization=Truncate  overflow=Wrap  en=off  latency=mult_latency  use_behavioral_HDL=on  opt=Speed  use_embedded=off  optimum_pipeline=off  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Triangular  block_type=mult
  repa : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  repb : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  a*b : Outport
  wires:
  a/1 -> repa/1(in)
  b/1 -> repb/1(in)
  repa/1(out) -> a_debus/1(bus_in)
  repb/1(out) -> b_debus/1(bus_in)
  a_debus/1(msb_out48) -> mult1/1
  b_debus/1(msb_out48) -> mult1/2
  a_debus/2(out47) -> mult2/1
  b_debus/2(out47) -> mult2/2
  a_debus/3(out46) -> mult3/1
  b_debus/3(out46) -> mult3/2
  a_debus/4(out45) -> mult4/1
  b_debus/4(out45) -> mult4/2
  a_debus/5(out44) -> mult5/1
  b_debus/5(out44) -> mult5/2
  a_debus/6(out43) -> mult6/1
  b_debus/6(out43) -> mult6/2
  a_debus/7(out42) -> mult7/1
  b_debus/7(out42) -> mult7/2
  a_debus/8(out41) -> mult8/1
  b_debus/8(out41) -> mult8/2
  a_debus/9(out40) -> mult9/1
  b_debus/9(out40) -> mult9/2
  a_debus/10(out39) -> mult10/1
  b_debus/10(out39) -> mult10/2
  a_debus/11(out38) -> mult11/1
  b_debus/11(out38) -> mult11/2
  a_debus/12(out37) -> mult12/1
  b_debus/12(out37) -> mult12/2
  a_debus/13(out36) -> mult13/1
  b_debus/13(out36) -> mult13/2
  a_debus/14(out35) -> mult14/1
  b_debus/14(out35) -> mult14/2
  a_debus/15(out34) -> mult15/1
  b_debus/15(out34) -> mult15/2
  a_debus/16(out33) -> mult16/1
  b_debus/16(out33) -> mult16/2
  a_debus/17(out32) -> mult17/1
  b_debus/17(out32) -> mult17/2
  a_debus/18(out31) -> mult18/1
  b_debus/18(out31) -> mult18/2
  a_debus/19(out30) -> mult19/1
  b_debus/19(out30) -> mult19/2
  a_debus/20(out29) -> mult20/1
  b_debus/20(out29) -> mult20/2
  a_debus/21(out28) -> mult21/1
  b_debus/21(out28) -> mult21/2
  a_debus/22(out27) -> mult22/1
  b_debus/22(out27) -> mult22/2
  a_debus/23(out26) -> mult23/1
  b_debus/23(out26) -> mult23/2
  a_debus/24(out25) -> mult24/1
  b_debus/24(out25) -> mult24/2
  a_debus/25(out24) -> mult25/1
  b_debus/25(out24) -> mult25/2
  a_debus/26(out23) -> mult26/1
  b_debus/26(out23) -> mult26/2
  a_debus/27(out22) -> mult27/1
  b_debus/27(out22) -> mult27/2
  a_debus/28(out21) -> mult28/1
  b_debus/28(out21) -> mult28/2
  a_debus/29(out20) -> mult29/1
  b_debus/29(out20) -> mult29/2
  a_debus/30(out19) -> mult30/1
  b_debus/30(out19) -> mult30/2
  a_debus/31(out18) -> mult31/1
  b_debus/31(out18) -> mult31/2
  a_debus/32(out17) -> mult32/1
  b_debus/32(out17) -> mult32/2
  a_debus/33(out16) -> mult33/1
  b_debus/33(out16) -> mult33/2
  a_debus/34(out15) -> mult34/1
  b_debus/34(out15) -> mult34/2
  a_debus/35(out14) -> mult35/1
  b_debus/35(out14) -> mult35/2
  a_debus/36(out13) -> mult36/1
  b_debus/36(out13) -> mult36/2
  a_debus/37(out12) -> mult37/1
  b_debus/37(out12) -> mult37/2
  a_debus/38(out11) -> mult38/1
  b_debus/38(out11) -> mult38/2
  a_debus/39(out10) -> mult39/1
  b_debus/39(out10) -> mult39/2
  a_debus/40(out9) -> mult40/1
  b_debus/40(out9) -> mult40/2
  a_debus/41(out8) -> mult41/1
  b_debus/41(out8) -> mult41/2
  a_debus/42(out7) -> mult42/1
  b_debus/42(out7) -> mult42/2
  a_debus/43(out6) -> mult43/1
  b_debus/43(out6) -> mult43/2
  a_debus/44(out5) -> mult44/1
  b_debus/44(out5) -> mult44/2
  a_debus/45(out4) -> mult45/1
  b_debus/45(out4) -> mult45/2
  a_debus/46(out3) -> mult46/1
  b_debus/46(out3) -> mult46/2
  a_debus/47(out2) -> mult47/1
  b_debus/47(out2) -> mult47/2
  a_debus/48(lsb_out1) -> mult48/1
  b_debus/48(lsb_out1) -> mult48/2
  mult1/1 -> a*b_bussify/1(in1)
  mult2/1 -> a*b_bussify/2(in2)
  mult3/1 -> a*b_bussify/3(in3)
  mult4/1 -> a*b_bussify/4(in4)
  mult5/1 -> a*b_bussify/5(in5)
  mult6/1 -> a*b_bussify/6(in6)
  mult7/1 -> a*b_bussify/7(in7)
  mult8/1 -> a*b_bussify/8(in8)
  mult9/1 -> a*b_bussify/9(in9)
  mult10/1 -> a*b_bussify/10(in10)
  mult11/1 -> a*b_bussify/11(in11)
  mult12/1 -> a*b_bussify/12(in12)
  mult13/1 -> a*b_bussify/13(in13)
  mult14/1 -> a*b_bussify/14(in14)
  mult15/1 -> a*b_bussify/15(in15)
  mult16/1 -> a*b_bussify/16(in16)
  mult17/1 -> a*b_bussify/17(in17)
  mult18/1 -> a*b_bussify/18(in18)
  mult19/1 -> a*b_bussify/19(in19)
  mult20/1 -> a*b_bussify/20(in20)
  mult21/1 -> a*b_bussify/21(in21)
  mult22/1 -> a*b_bussify/22(in22)
  mult23/1 -> a*b_bussify/23(in23)
  mult24/1 -> a*b_bussify/24(in24)
  mult25/1 -> a*b_bussify/25(in25)
  mult26/1 -> a*b_bussify/26(in26)
  mult27/1 -> a*b_bussify/27(in27)
  mult28/1 -> a*b_bussify/28(in28)
  mult29/1 -> a*b_bussify/29(in29)
  mult30/1 -> a*b_bussify/30(in30)
  mult31/1 -> a*b_bussify/31(in31)
  mult32/1 -> a*b_bussify/32(in32)
  mult33/1 -> a*b_bussify/33(in33)
  mult34/1 -> a*b_bussify/34(in34)
  mult35/1 -> a*b_bussify/35(in35)
  mult36/1 -> a*b_bussify/36(in36)
  mult37/1 -> a*b_bussify/37(in37)
  mult38/1 -> a*b_bussify/38(in38)
  mult39/1 -> a*b_bussify/39(in39)
  mult40/1 -> a*b_bussify/40(in40)
  mult41/1 -> a*b_bussify/41(in41)
  mult42/1 -> a*b_bussify/42(in42)
  mult43/1 -> a*b_bussify/43(in43)
  mult44/1 -> a*b_bussify/44(in44)
  mult45/1 -> a*b_bussify/45(in45)
  mult46/1 -> a*b_bussify/46(in46)
  mult47/1 -> a*b_bussify/47(in47)
  mult48/1 -> a*b_bussify/48(in48)
  a*b_bussify/1(bus_out) -> a*b/1
