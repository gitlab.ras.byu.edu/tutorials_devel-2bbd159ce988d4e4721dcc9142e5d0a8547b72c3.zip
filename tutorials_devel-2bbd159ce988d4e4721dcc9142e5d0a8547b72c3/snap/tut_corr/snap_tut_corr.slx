simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 28 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum ==
  sync : Inport
  din0 : Inport  Port=2
  reo_in0 : Inport  Port=3
  din1 : Inport  Port=4
  reo_in1 : Inport  Port=5
  din2 : Inport  Port=6
  reo_in2 : Inport  Port=7
  din3 : Inport  Port=8
  reo_in3 : Inport  Port=9
  complex_conj0 : Subsystem  AncestorBlock=casper_library_misc/complex_conj  mask(complex_conj){n_inputs=3, n_bits=18, bin_pt=17, csp_latency=0, overflow=Wrap, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "number simultaneous inputs"; n_bits "input bitwidth"; bin_pt "input binary point"; csp_latency "latency"; overflow "overflow strategy"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"
      mask help: Finds the complex conjugate of complex inputs.
      mask init:
      | complex_conj_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'bin_pt', bin_pt, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...        
      |     'csp_latency', csp_latency, ...
      |     'overflow', overflow);
  complex_conj1 : Subsystem  AncestorBlock=casper_library_misc/complex_conj  mask(complex_conj){n_inputs=3, n_bits=18, bin_pt=17, csp_latency=0, overflow=Wrap, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "number simultaneous inputs"; n_bits "input bitwidth"; bin_pt "input binary point"; csp_latency "latency"; overflow "overflow strategy"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"
      mask help: Finds the complex conjugate of complex inputs.
      mask init:
      | complex_conj_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'bin_pt', bin_pt, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...        
      |     'csp_latency', csp_latency, ...
      |     'overflow', overflow);
  complex_conj2 : Subsystem  AncestorBlock=casper_library_misc/complex_conj  mask(complex_conj){n_inputs=3, n_bits=18, bin_pt=17, csp_latency=0, overflow=Wrap, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "number simultaneous inputs"; n_bits "input bitwidth"; bin_pt "input binary point"; csp_latency "latency"; overflow "overflow strategy"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"
      mask help: Finds the complex conjugate of complex inputs.
      mask init:
      | complex_conj_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'bin_pt', bin_pt, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...        
      |     'csp_latency', csp_latency, ...
      |     'overflow', overflow);
  complex_conj3 : Subsystem  AncestorBlock=casper_library_misc/complex_conj  mask(complex_conj){n_inputs=3, n_bits=18, bin_pt=17, csp_latency=0, overflow=Wrap, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "number simultaneous inputs"; n_bits "input bitwidth"; bin_pt "input binary point"; csp_latency "latency"; overflow "overflow strategy"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"
      mask help: Finds the complex conjugate of complex inputs.
      mask init:
      | complex_conj_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'bin_pt', bin_pt, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...        
      |     'csp_latency', csp_latency, ...
      |     'overflow', overflow);
  constant : xbsIndex_r4/Constant  const=256  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=9  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + bram_latency + negate_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : Subsystem  AncestorBlock=casper_library_bus/bus_mux  mask(bus_mux){n_inputs=2, n_bits=[18 18 18], cmplx=on, misc=off, mux_latency=1}
      mask prompts: n_inputs "number of inputs"; n_bits "input bit widths"; cmplx "complex data"; misc "misc support"; mux_latency "mux latency"
      mask help: Mux components of bus
      mask init:
      | bus_mux_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'mux_latency', mux_latency);
  dmux1 : Subsystem  AncestorBlock=casper_library_bus/bus_mux  mask(bus_mux){n_inputs=2, n_bits=[18 18 18], cmplx=on, misc=off, mux_latency=1}
      mask prompts: n_inputs "number of inputs"; n_bits "input bit widths"; cmplx "complex data"; misc "misc support"; mux_latency "mux latency"
      mask help: Mux components of bus
      mask init:
      | bus_mux_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'mux_latency', mux_latency);
  dmux2 : Subsystem  AncestorBlock=casper_library_bus/bus_mux  mask(bus_mux){n_inputs=2, n_bits=[18 18 18], cmplx=on, misc=off, mux_latency=1}
      mask prompts: n_inputs "number of inputs"; n_bits "input bit widths"; cmplx "complex data"; misc "misc support"; mux_latency "mux latency"
      mask help: Mux components of bus
      mask init:
      | bus_mux_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'mux_latency', mux_latency);
  dmux3 : Subsystem  AncestorBlock=casper_library_bus/bus_mux  mask(bus_mux){n_inputs=2, n_bits=[18 18 18], cmplx=on, misc=off, mux_latency=1}
      mask prompts: n_inputs "number of inputs"; n_bits "input bit widths"; cmplx "complex data"; misc "misc support"; mux_latency "mux latency"
      mask help: Mux components of bus
      mask init:
      | bus_mux_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'n_bits', n_bits, ...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'mux_latency', mux_latency);
  relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  sel_replicate0 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=n_inputs, csp_latency=ceil(log2(n_inputs)), misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sel_replicate1 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=n_inputs, csp_latency=ceil(log2(n_inputs)), misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sel_replicate2 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=n_inputs, csp_latency=ceil(log2(n_inputs)), misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sel_replicate3 : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=n_inputs, csp_latency=ceil(log2(n_inputs)), misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sync_delay0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + bram_latency + negate_latency - ceil(log2(n_inputs))  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1 + ceil(log2(n_inputs))  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout0 : Outport  Port=2
  dout1 : Outport  Port=3
  dout2 : Outport  Port=4
  dout3 : Outport  Port=5
  wires:
  sync/1 -> sync_delay0/1
  sync_delay0/1 -> counter/1, sync_delay1/1
  counter/1 -> relational/1
  constant/1 -> relational/2
  sync_delay1/1 -> sync_out/1
  din0/1 -> delay0/1
  reo_in0/1 -> complex_conj0/1(z)
  relational/1 -> sel_replicate0/1(in), sel_replicate1/1(in), sel_replicate2/1(in), sel_replicate3/1(in)
  sel_replicate0/1(out) -> dmux0/1(sel)
  delay0/1 -> dmux0/2(d0)
  complex_conj0/1(z*) -> dmux0/3(d1)
  dmux0/1(out) -> dout0/1
  din1/1 -> delay1/1
  reo_in1/1 -> complex_conj1/1(z)
  sel_replicate1/1(out) -> dmux1/1(sel)
  delay1/1 -> dmux1/2(d0)
  complex_conj1/1(z*) -> dmux1/3(d1)
  dmux1/1(out) -> dout1/1
  din2/1 -> delay2/1
  reo_in2/1 -> complex_conj2/1(z)
  sel_replicate2/1(out) -> dmux2/1(sel)
  delay2/1 -> dmux2/2(d0)
  complex_conj2/1(z*) -> dmux2/3(d1)
  dmux2/1(out) -> dout2/1
  din3/1 -> delay3/1
  reo_in3/1 -> complex_conj3/1(z)
  sel_replicate3/1(out) -> dmux3/1(sel)
  delay3/1 -> dmux3/2(d0)
  complex_conj3/1(z*) -> dmux3/3(d1)
  dmux3/1(out) -> dout3/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=1, outputWidth=8, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  optimize=Speed  use_rpm=on  dbl_ovrd=off  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=1, outputWidth=1, outputBinaryPt=0, outputArithmeticType=2, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_lsb_out1) -> buf0/3(we)
  addr_expand/1(msb_lsb_out1) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_odd ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=1, outputWidth=8, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  optimize=Speed  use_rpm=on  dbl_ovrd=off  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=1, outputWidth=1, outputBinaryPt=0, outputArithmeticType=2, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=0, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_lsb_out1) -> buf0/3(we)
  addr_expand/1(msb_lsb_out1) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3
