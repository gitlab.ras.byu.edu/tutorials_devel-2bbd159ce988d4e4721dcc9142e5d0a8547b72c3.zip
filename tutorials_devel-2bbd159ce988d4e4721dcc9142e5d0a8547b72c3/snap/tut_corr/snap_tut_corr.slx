simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 17 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x ==
  sync : Inport
  even : Inport  Port=2
  odd : Inport  Port=3
  c0 : xbsIndex_r4/Constant  const=2^(FFTSize-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  c1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  count : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  d{0,3..6} (5 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  d2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=add_latency + conv_latency + 1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay0 : Subsystem  AncestorBlock=casper_library_delays/delay_bram  mask(delay_bram){DelayLen=256, bram_latency=3, use_dsp48=off, async=off}
      mask prompts: DelayLen "Delay By:"; bram_latency "BRAM Latency"; use_dsp48 "Use DSP48"; async "asynchronous operation"
      mask help: A delay block that uses BRAM for its storage.
      mask init:
      | delay_bram_init(gcb, ...
      |     'DelayLen', DelayLen, ...
      |     'bram_latency', bram_latency, ...
      |     'use_dsp48', use_dsp48, ...
      |     'async', async);
  delay1 : Subsystem  AncestorBlock=casper_library_delays/delay_bram  mask(delay_bram){DelayLen=256, bram_latency=3, use_dsp48=off, async=off}
      mask prompts: DelayLen "Delay By:"; bram_latency "BRAM Latency"; use_dsp48 "Use DSP48"; async "asynchronous operation"
      mask help: A delay block that uses BRAM for its storage.
      mask init:
      | delay_bram_init(gcb, ...
      |     'DelayLen', DelayLen, ...
      |     'bram_latency', bram_latency, ...
      |     'use_dsp48', use_dsp48, ...
      |     'async', async);
  en_even : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  en_odd : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  en_out : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  hilbert0 : Subsystem  AncestorBlock=casper_library_ffts_internal/hilbert  mask(hilbert){n_inputs=3, BitWidth=18, bin_pt_in=17, add_latency=1, conv_latency=conv_latency, misc=off, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "Number simultaneous inputs"; BitWidth "Bit Width"; bin_pt_in "Binary point in"; add_latency "Add Latency"; conv_latency "Convert Latency"; misc "Miscellaneous input"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"
      mask help: FFT internal block. Computes (a+b*)/2 and (a-b*)/2i. If a = w + ix and b = y + iz, then: a+b = (w+y)/2 + i(x-z)/2 a-b = (x+z)/2 + i(y-w)/2
      mask init:
      | hilbert_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'BitWidth', BitWidth, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'misc', misc);
  hilbert1 : Subsystem  AncestorBlock=casper_library_ffts_internal/hilbert  mask(hilbert){n_inputs=3, BitWidth=18, bin_pt_in=17, add_latency=1, conv_latency=conv_latency, misc=off, floating_point=off, float_type=single, exp_width=8, frac_width=24}
      mask prompts: n_inputs "Number simultaneous inputs"; BitWidth "Bit Width"; bin_pt_in "Binary point in"; add_latency "Add Latency"; conv_latency "Convert Latency"; misc "Miscellaneous input"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"
      mask help: FFT internal block. Computes (a+b*)/2 and (a-b*)/2i. If a = w + ix and b = y + iz, then: a+b = (w+y)/2 + i(x-z)/2 a-b = (x+z)/2 + i(y-w)/2
      mask init:
      | hilbert_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'BitWidth', BitWidth, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'misc', misc);
  mirror_spectrum : Subsystem  AncestorBlock=casper_library_ffts_internal/mirror_spectrum  mask(mirror_spectrum){n_inputs=3, FFTSize=9, input_bitwidth=18, bin_pt_in=bin_pt, floating_point=off, float_type=single, exp_width=8, frac_width=24, bram_latency=9, negate_latency=0, negate_mode=logic, async=off}
      mask prompts: n_inputs "Number simultaneous inputs (2*?)"; FFTSize "Size of FFT (2^?)"; input_bitwidth "Input Bit Width"; bin_pt_in "Binary point in"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; bram_latency "BRAM Latency"; negate_latency "Negate Latency"; negate_mode "Negate mode"; async "Asynchronous operation"
      mask help: FFT internal block.
      mask init:
      | mirror_spectrum_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'input_bitwidth', input_bitwidth, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bram_latency', bram_latency, ...
      |     'negate_latency', negate_latency, ...
      |     'negate_mode', negate_mode, ...
      |     'async', async);
  mux{0..3} (4 alike) : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  r0 : xbsIndex_r4/Relational  mode=a=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  r1 : xbsIndex_r4/Relational  mode=a=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  reorder_even : Subsystem  AncestorBlock=casper_library_reorder/reorder  mask(reorder){map=[0 128 64 192 32 160 96 224 16 144 80 208 48 176 112 240 8 136 72 200 40 168 104 232 24 152 88 216 56 184 120 248 4 132 68 196 36 164 100 228 20 148 84 212 52 180 116 244 12 140 76 204 44 172 108 236 28 156 92 220 60 188 124 252 2 130 66 194 34 162 98 226 18 146 82 210 50 178 114 242 10 138 74 202 42 170 106 234 26 154 90 218 58 186 122 250 6 134 70 198 38 166 102 230 22 150 86 214 54 182 118 246 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, n_bits=108, n_inputs=1, bram_latency=3, map_latency=3, fanout_latency=1, double_buffer=0, bram_map=on, software_controlled=off}
      mask prompts: map "Output Order:"; n_bits "Data width in"; n_inputs "Number of inputs"; bram_latency "BRAM Latency"; map_latency "Map Latency"; fanout_latency "Fanout latency"; double_buffer "Double Buffer"; bram_map "Use BlockRAM for Map"; software_controlled "Use runtime software control"
      mask init:
      | reorder_init(gcb, ...
      |     'map', map, ...
      |     'n_bits', n_bits, ...
      |     'n_inputs', n_inputs, ...
      |     'bram_latency', bram_latency, ...
      |     'map_latency', map_latency, ...
      |     'fanout_latency', fanout_latency, ...
      |     'double_buffer', double_buffer, ...
      |     'bram_map', bram_map, ...
      |     'software_controlled', software_controlled);
  reorder_odd : Subsystem  AncestorBlock=casper_library_reorder/reorder  mask(reorder){map=[255 127 191 63 223 95 159 31 239 111 175 47 207 79 143 15 247 119 183 55 215 87 151 23 231 103 167 39 199 71 135 7 251 123 187 59 219 91 155 27 235 107 171 43 203 75 139 11 243 115 179 51 211 83 147 19 227 99 163 35 195 67 131 3 253 125 189 61 221 93 157 29 237 109 173 45 205 77 141 13 245 117 181 53 213 85 149 21 229 101 165 37 197 69 133 5 249 121 185 57 217 89 153 25 233 105 169 41 201 73 137 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, n_bits=108, n_inputs=1, bram_latency=3, map_latency=3, fanout_latency=1, double_buffer=0, bram_map=on, software_controlled=off}
      mask prompts: map "Output Order:"; n_bits "Data width in"; n_inputs "Number of inputs"; bram_latency "BRAM Latency"; map_latency "Map Latency"; fanout_latency "Fanout latency"; double_buffer "Double Buffer"; bram_map "Use BlockRAM for Map"; software_controlled "Use runtime software control"
      mask init:
      | reorder_init(gcb, ...
      |     'map', map, ...
      |     'n_bits', n_bits, ...
      |     'n_inputs', n_inputs, ...
      |     'bram_latency', bram_latency, ...
      |     'map_latency', map_latency, ...
      |     'fanout_latency', fanout_latency, ...
      |     'double_buffer', double_buffer, ...
      |     'bram_map', bram_map, ...
      |     'software_controlled', software_controlled);
  reorder_out : Subsystem  AncestorBlock=casper_library_reorder/reorder  mask(reorder){map=[255 254 253 252 251 250 249 248 247 246 245 244 243 242 241 240 239 238 237 236 235 234 233 232 231 230 229 228 227 226 225 224 223 222 221 220 219 218 217 216 215 214 213 212 211 210 209 208 207 206 205 204 203 202 201 200 199 198 197 196 195 194 193 192 191 190 189 188 187 186 185 184 183 182 181 180 179 178 177 176 175 174 173 172 171 170 169 168 167 166 165 164 163 162 161 160 159 158 157 156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, n_bits=108, n_inputs=4, bram_latency=bram_latency, map_latency=3, fanout_latency=1, double_buffer=0, bram_map=on, software_controlled=off}
      mask prompts: map "Output Order:"; n_bits "Data width in"; n_inputs "Number of inputs"; bram_latency "BRAM Latency"; map_latency "Map Latency"; fanout_latency "Fanout latency"; double_buffer "Double Buffer"; bram_map "Use BlockRAM for Map"; software_controlled "Use runtime software control"
      mask init:
      | reorder_init(gcb, ...
      |     'map', map, ...
      |     'n_bits', n_bits, ...
      |     'n_inputs', n_inputs, ...
      |     'bram_latency', bram_latency, ...
      |     'map_latency', map_latency, ...
      |     'fanout_latency', fanout_latency, ...
      |     'double_buffer', double_buffer, ...
      |     'bram_map', bram_map, ...
      |     'software_controlled', software_controlled);
  sync_delay : Subsystem  AncestorBlock=casper_library_delays/sync_delay  mask(sync_delay){DelayLen=256}
      mask prompts: DelayLen "Delay Length:"
      mask help: Delay an infrequent boolean pulse by the specified number of clocks.
      mask init:
      | BitWidth = max(2, ceil(log2(DelayLen+1)));
      | UseCounter = 1;
      | if DelayLen == 0,
      | 	UseCounter = 0;
      | end
  t{0..4} (5 alike) : Terminator
  sync_out : Outport
  pol1_out : Outport  Port=2
  pol2_out : Outport  Port=3
  pol3_out : Outport  Port=4
  pol4_out : Outport  Port=5
  wires:
  even/1 -> reorder_even/3(din0)
  sync/1 -> reorder_even/1(sync), reorder_odd/1(sync)
  odd/1 -> reorder_odd/3(din0)
  reorder_odd/1(sync_out) -> t0/1
  reorder_odd/2(valid) -> t1/1
  reorder_even/2(valid) -> t2/1
  en_even/1 -> reorder_even/2(en)
  en_odd/1 -> reorder_odd/2(en)
  c0/1 -> r0/1
  count/1 -> r0/2, r1/1
  c1/1 -> r1/2
  reorder_odd/3(dout0) -> d0/1
  reorder_even/1(sync_out) -> count/1, d2/1
  r0/1 -> mux0/1, mux3/1
  r1/1 -> mux1/1, mux2/1
  reorder_even/3(dout0) -> mux0/2, mux1/3, mux2/2, mux3/3
  d0/1 -> mux0/3, mux1/2, mux2/3, mux3/2
  d2/1 -> sync_delay/1(In)
  mux0/1 -> hilbert0/1(a)
  mux1/1 -> hilbert0/2(b)
  mux2/1 -> hilbert1/1(a)
  mux3/1 -> hilbert1/2(b)
  hilbert0/1(even) -> delay0/1(din)
  hilbert0/2(odd) -> delay1/1(din)
  delay0/1(dout) -> mirror_spectrum/2(din0), reorder_out/3(din0)
  delay1/1(dout) -> mirror_spectrum/4(din1), reorder_out/4(din1)
  hilbert1/1(even) -> mirror_spectrum/6(din2), reorder_out/5(din2)
  hilbert1/2(odd) -> mirror_spectrum/8(din3), reorder_out/6(din3)
  mirror_spectrum/1(sync_out) -> sync_out/1
  mirror_spectrum/2(dout0) -> pol1_out/1
  mirror_spectrum/3(dout1) -> pol2_out/1
  mirror_spectrum/4(dout2) -> pol3_out/1
  mirror_spectrum/5(dout3) -> pol4_out/1
  sync_delay/1(Out) -> mirror_spectrum/1(sync), reorder_out/1(sync)
  en_out/1 -> reorder_out/2(en)
  reorder_out/1(sync_out) -> t3/1
  reorder_out/2(valid) -> t4/1
  reorder_out/3(dout0) -> d3/1
  d3/1 -> mirror_spectrum/3(reo_in0)
  reorder_out/4(dout1) -> d4/1
  d4/1 -> mirror_spectrum/5(reo_in1)
  reorder_out/5(dout2) -> d5/1
  d5/1 -> mirror_spectrum/7(reo_in2)
  reorder_out/6(dout3) -> d6/1
  d6/1 -> mirror_spectrum/9(reo_in3)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core ==
  sync : Inport
  shift : Inport  Port=2
  pol1 : Inport  Port=3
  pol2 : Inport  Port=4
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=3  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  fft_stage_1 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=1, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=on, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_2 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=2, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_3 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=3, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_4 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=4, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_5 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=5, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_6 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=6, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_7 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=7, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_8 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=8, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  fft_stage_9 : Subsystem  AncestorBlock=casper_library_ffts/fft_stage_n  mask(fft_stage_n){n_inputs=3, FFTSize=9, FFTStage=9, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bram=off, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, downshift=off, dsp48_adders=off}
      mask prompts: n_inputs "Number inputs"; FFTSize "Size of FFT: (2^? pts)"; FFTStage "Stage of FFT:"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; async "Asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bram "Implement Delays in BRAM"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for mutlipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | fft_stage_n_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'FFTStage', FFTStage, ...
      |     'input_bit_width', input_bit_width, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'coeff_bit_width', coeff_bit_width, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'bitgrowth', bitgrowth, ...
      |     'downshift', downshift, ...
      |     'async', async, ...
      |     'add_latency', add_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'delays_bram', delays_bram, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'use_hdl', use_hdl, ...
      |     'use_embedded', use_embedded, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'dsp48_adders', dsp48_adders);
  sync_out : Outport
  out1 : Outport  Port=2
  out2 : Outport  Port=3
  of : Outport  Port=4
  wires:
  fft_stage_1/1(out1) -> fft_stage_2/1(in1)
  fft_stage_1/2(out2) -> fft_stage_2/2(in2)
  fft_stage_1/3(of) -> fft_stage_2/3(of_in)
  fft_stage_1/4(sync_out) -> fft_stage_2/4(sync)
  shift/1 -> fft_stage_2/5(shift), fft_stage_3/5(shift), fft_stage_4/5(shift), fft_stage_5/5(shift), fft_stage_6/5(shift), fft_stage_7/5(shift), fft_stage_8/5(shift), fft_stage_9/5(shift), fft_stage_1/5(shift)
  fft_stage_2/1(out1) -> fft_stage_3/1(in1)
  fft_stage_2/2(out2) -> fft_stage_3/2(in2)
  fft_stage_2/3(of) -> fft_stage_3/3(of_in)
  fft_stage_2/4(sync_out) -> fft_stage_3/4(sync)
  fft_stage_3/1(out1) -> fft_stage_4/1(in1)
  fft_stage_3/2(out2) -> fft_stage_4/2(in2)
  fft_stage_3/3(of) -> fft_stage_4/3(of_in)
  fft_stage_3/4(sync_out) -> fft_stage_4/4(sync)
  fft_stage_4/1(out1) -> fft_stage_5/1(in1)
  fft_stage_4/2(out2) -> fft_stage_5/2(in2)
  fft_stage_4/3(of) -> fft_stage_5/3(of_in)
  fft_stage_4/4(sync_out) -> fft_stage_5/4(sync)
  fft_stage_5/1(out1) -> fft_stage_6/1(in1)
  fft_stage_5/2(out2) -> fft_stage_6/2(in2)
  fft_stage_5/3(of) -> fft_stage_6/3(of_in)
  fft_stage_5/4(sync_out) -> fft_stage_6/4(sync)
  fft_stage_6/1(out1) -> fft_stage_7/1(in1)
  fft_stage_6/2(out2) -> fft_stage_7/2(in2)
  fft_stage_6/3(of) -> fft_stage_7/3(of_in)
  fft_stage_6/4(sync_out) -> fft_stage_7/4(sync)
  fft_stage_7/1(out1) -> fft_stage_8/1(in1)
  fft_stage_7/2(out2) -> fft_stage_8/2(in2)
  fft_stage_7/3(of) -> fft_stage_8/3(of_in)
  fft_stage_7/4(sync_out) -> fft_stage_8/4(sync)
  fft_stage_8/1(out1) -> fft_stage_9/1(in1)
  fft_stage_8/2(out2) -> fft_stage_9/2(in2)
  fft_stage_8/3(of) -> fft_stage_9/3(of_in)
  fft_stage_8/4(sync_out) -> fft_stage_9/4(sync)
  pol1/1 -> fft_stage_1/1(in1)
  pol2/1 -> fft_stage_1/2(in2)
  Constant/1 -> fft_stage_1/3(of_in)
  sync/1 -> fft_stage_1/4(sync)
  fft_stage_9/1(out1) -> out1/1
  fft_stage_9/2(out2) -> out2/1
  fft_stage_9/3(of) -> of/1
  fft_stage_9/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/even_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/odd_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/pol0_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/pol1_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1
