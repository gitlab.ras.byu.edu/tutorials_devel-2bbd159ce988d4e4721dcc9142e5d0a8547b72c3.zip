simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 75 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_add ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18  18  18  18  18  18], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addsub{1..6} (6 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  dbl_ovrd=off  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[19  19  19  19  19  19], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out6) -> addsub1/1
  b_debus/1(msb_out6) -> addsub1/2
  a_debus/2(out5) -> addsub2/1
  b_debus/2(out5) -> addsub2/2
  a_debus/3(out4) -> addsub3/1
  b_debus/3(out4) -> addsub3/2
  a_debus/4(out3) -> addsub4/1
  b_debus/4(out3) -> addsub4/2
  a_debus/5(out2) -> addsub5/1
  b_debus/5(out2) -> addsub5/2
  a_debus/6(lsb_out1) -> addsub6/1
  b_debus/6(lsb_out1) -> addsub6/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  op_bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(din)
  debus/2(out11) -> conv2/1(din)
  debus/3(out10) -> conv3/1(din)
  debus/4(out9) -> conv4/1(din)
  debus/5(out8) -> conv5/1(din)
  debus/6(out7) -> conv6/1(din)
  debus/7(out6) -> conv7/1(din)
  debus/8(out5) -> conv8/1(din)
  debus/9(out4) -> conv9/1(din)
  debus/10(out3) -> conv10/1(din)
  debus/11(out2) -> conv11/1(din)
  debus/12(lsb_out1) -> conv12/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv{1..12} (12 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1
  debus/2(out11) -> conv2/1
  debus/3(out10) -> conv3/1
  debus/4(out9) -> conv4/1
  debus/5(out8) -> conv5/1
  debus/6(out7) -> conv6/1
  debus/7(out6) -> conv7/1
  debus/8(out5) -> conv8/1
  debus/9(out4) -> conv9/1
  debus/10(out3) -> conv10/1
  debus/11(out2) -> conv11/1
  debus/12(lsb_out1) -> conv12/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(in)
  debus/2(out11) -> conv2/1(in)
  debus/3(out10) -> conv3/1(in)
  debus/4(out9) -> conv4/1(in)
  debus/5(out8) -> conv5/1(in)
  debus/6(out7) -> conv6/1(in)
  debus/7(out6) -> conv7/1(in)
  debus/8(out5) -> conv8/1(in)
  debus/9(out4) -> conv9/1(in)
  debus/10(out3) -> conv10/1(in)
  debus/11(out2) -> conv11/1(in)
  debus/12(lsb_out1) -> conv12/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_relational ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4], outputBinaryPt=[0], outputArithmeticType=[0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[4  4  4], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  relational1 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  relational2 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  relational3 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  a!=b : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> relational1/1, relational2/1, relational3/1
  b_debus/1(msb_out3) -> relational1/2
  b_debus/2(out2) -> relational2/2
  b_debus/3(lsb_out1) -> relational3/2
  relational1/1 -> bussify/1(in1)
  relational2/1 -> bussify/2(in2)
  relational3/1 -> bussify/3(in3)
  bussify/1(bus_out) -> a!=b/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  scale{1..12} (12 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> scale1/1
  debus/2(out11) -> scale2/1
  debus/3(out10) -> scale3/1
  debus/4(out9) -> scale4/1
  debus/5(out8) -> scale5/1
  debus/6(out7) -> scale6/1
  debus/7(out6) -> scale7/1
  debus/8(out5) -> scale8/1
  debus/9(out4) -> scale9/1
  debus/10(out3) -> scale10/1
  debus/11(out2) -> scale11/1
  debus/12(lsb_out1) -> scale12/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/bus_sub ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18  18  18  18  18  18], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addsub{1..6} (6 alike) : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  dbl_ovrd=off  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[19  19  19  19  19  19], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out6) -> addsub1/1
  b_debus/1(msb_out6) -> addsub1/2
  a_debus/2(out5) -> addsub2/1
  b_debus/2(out5) -> addsub2/2
  a_debus/3(out4) -> addsub3/1
  b_debus/3(out4) -> addsub3/2
  a_debus/4(out3) -> addsub4/1
  b_debus/4(out3) -> addsub4/2
  a_debus/5(out2) -> addsub5/1
  b_debus/5(out2) -> addsub5/2
  a_debus/6(lsb_out1) -> addsub6/1
  b_debus/6(lsb_out1) -> addsub6/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  op_bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7/butterfly_direct/munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[2 2 2 2 2 2], outputBinaryPt=[0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/1(msb_out6) -> join/1(in1)
  split/4(out3) -> join/2(in2)
  split/2(out5) -> join/3(in3)
  split/5(out2) -> join/4(in4)
  split/3(out4) -> join/5(in5)
  split/6(lsb_out1) -> join/6(in6)
