simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 25 of 131)

== system snap_tut_corr/dir_x0/bb/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/bb/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bb/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bb/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/bb/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system snap_tut_corr/dir_x0/bb/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system snap_tut_corr/dir_x0/bc/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/bc/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bc/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bc/imag/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/bc/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/bc/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bc/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/bc/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/bc/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system snap_tut_corr/dir_x0/bc/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system snap_tut_corr/dir_x0/bc/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x0/bc/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x0/cc/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/cc/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/cc/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/cc/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/cc/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x0/cc/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x1/aa/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x1/aa/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/aa/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/aa/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x1/aa/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x1/aa/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x1/ab/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x1/ab/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/ab/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/ab/imag/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x1/ab/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x1/ab/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/ab/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x1/ab/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x1/ab/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system snap_tut_corr/dir_x1/ab/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system snap_tut_corr/dir_x1/ab/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1
