simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 8 of 131)

== system snap_tut_corr/pulse_ext2/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/pulse_ext6/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/quant0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/quant0/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=10, data_width=32, data_bin_pt=0, init_vals=[0     1     2     3     4     5     6     7     8     9    10    11    12    13    14    15    16    17    18    19    20    21    22    23    24    25    26    27    28    29    30    31    32    33    34    35    36    37    38    39    40    41    42    43    44    45    46    47    48    49    50    51    52    53    54    55    56    57    58    59    60    61    62    63    64    65    66  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_quant0_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant0_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant0_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_quant0_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_quant0_coeffs_data_out/1
  snap_tut_corr_quant0_coeffs_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_quant0_coeffs_addr/1
  convert_din1/1 -> snap_tut_corr_quant0_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_quant0_coeffs_we/1 -> Terminator2/1
  snap_tut_corr_quant0_coeffs_data_in/1 -> Terminator1/1
  snap_tut_corr_quant0_coeffs_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_quant0_coeffs_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/quant0/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/quant0/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/quant1/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/quant1/coeffs ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=10, data_width=32, data_bin_pt=0, init_vals=[0     1     2     3     4     5     6     7     8     9    10    11    12    13    14    15    16    17    18    19    20    21    22    23    24    25    26    27    28    29    30    31    32    33    34    35    36    37    38    39    40    41    42    43    44    45    46    47    48    49    50    51    52    53    54    55    56    57    58    59    60    61    62    63    64    65    66  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_quant1_coeffs_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant1_coeffs_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_quant1_coeffs_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_quant1_coeffs_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_quant1_coeffs_data_out/1
  snap_tut_corr_quant1_coeffs_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_quant1_coeffs_addr/1
  convert_din1/1 -> snap_tut_corr_quant1_coeffs_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_quant1_coeffs_we/1 -> Terminator2/1
  snap_tut_corr_quant1_coeffs_data_in/1 -> Terminator1/1
  snap_tut_corr_quant1_coeffs_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_quant1_coeffs_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/quant1/round0 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/quant1/round1 ==
  din : Inport
  scale : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Concat2 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant4 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant5 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=27  bin_pt=18  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant6 : xbsIndex_r4/Constant  const=7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant7 : xbsIndex_r4/Constant  const=-7/8  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=4  bin_pt=3  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Convert2 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert3 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization="Round  (unbiased: Even Values)"  overflow=Wrap  en=off  latency=2  pipeline=on  dbl_ovrd=off  block_type=convert
  Logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=4  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mult : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mult1 : xbsIndex_r4/Mult  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  en=off  latency=4  use_behavioral_HDL=off  opt=Speed  use_embedded=on  optimum_pipeline=on  pipeline=on  dbl_ovrd=off  use_rpm=on  placement_style=Rectangular shape  block_type=mult
  Mux : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux1 : xbsIndex_r4/Mux  inputs=3  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  Reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=4  block_type=reinterpret
  Relational : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational2 : xbsIndex_r4/Relational  mode=a>b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Relational3 : xbsIndex_r4/Relational  mode=a<b  op_type=Bool  en=off  latency=2  dbl_ovrd=off  block_type=relational
  Slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  clip : Outport  Port=2
  wires:
  Slice4/1 -> Reinterpret/1
  Reinterpret2/1 -> Concat/1
  Slice5/1 -> Reinterpret1/1
  Reinterpret3/1 -> Concat/2
  din/1 -> Slice4/1, Slice5/1
  Concat/1 -> dout/1
  Reinterpret1/1 -> Mult1/1
  Reinterpret/1 -> Mult/1
  scale/1 -> Reinterpret4/1
  Convert2/1 -> Mux/2
  Concat1/1 -> Mux/1
  Constant/1 -> Relational/2
  Constant1/1 -> Relational1/2
  Constant2/1 -> Mux/3
  Constant3/1 -> Mux/4
  Relational/1 -> Concat1/2, Logical1/1
  Relational1/1 -> Concat1/1, Logical1/2
  Convert3/1 -> Mux1/2
  Concat2/1 -> Mux1/1
  Constant4/1 -> Relational2/2
  Constant5/1 -> Relational3/2
  Constant6/1 -> Mux1/3
  Constant7/1 -> Mux1/4
  Relational2/1 -> Concat2/2, Logical1/4
  Relational3/1 -> Concat2/1, Logical1/3
  Mux/1 -> Reinterpret2/1
  Mux1/1 -> Reinterpret3/1
  Mult1/1 -> Convert3/1, Relational2/1, Relational3/1
  Mult/1 -> Convert2/1, Relational/1, Relational1/1
  Logical1/1 -> clip/1
  Reinterpret4/1 -> Mult1/2, Mult/2

== system snap_tut_corr/quant2/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1
