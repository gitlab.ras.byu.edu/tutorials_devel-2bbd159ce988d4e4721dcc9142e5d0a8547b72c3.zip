simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 27 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0 ==
  a : Inport
  b : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  add_even_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=0, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  add_odd_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=0, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[19 19 19 19 19 19 19 19 19 19 19 19], bin_pt_in=bin_pt_in+1, cmplx=off, n_bits_out=18, bin_pt_out=bin_pt_in, quantization=2, overflow=0, csp_latency=conv_latency, of=off, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=4, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand_a : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand_b : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale  mask(bus_scale){n_bits_in=[19 19 19 19 19 19 19 19 19 19 19 19], bin_pt_in=bin_pt_in, type_in=1, cmplx=off, scale_factor=-1, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; type_in "input types"; cmplx "input complex"; scale_factor "scale factor (2^?)"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_scale_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'type_in', type_in, ...
      |     'cmplx', cmplx, ...
      |     'scale_factor', scale_factor, ...
      |     'misc', misc);
  munge_a : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_b : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_even : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_odd : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  ri_to_c : casper_library_misc/ri_to_c
  ri_to_c1 : casper_library_misc/ri_to_c
  sub_even_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=1, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  sub_odd_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=1, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  even : Outport
  odd : Outport  Port=2
  wires:
  b/1 -> munge_b/1(din)
  a/1 -> munge_a/1(din)
  munge_a/1(dout) -> bus_expand_a/1(bus_in)
  munge_b/1(dout) -> bus_expand_b/1(bus_in)
  bus_expand_a/1(msb_out2) -> add_even_real/1(a), sub_odd_imag/2(b)
  bus_expand_b/1(msb_out2) -> add_even_real/2(b), sub_odd_imag/1(a)
  bus_expand_a/2(lsb_out1) -> sub_even_imag/1(a), add_odd_real/1(a)
  bus_expand_b/2(lsb_out1) -> sub_even_imag/2(b), add_odd_real/2(b)
  add_even_real/1(dout) -> Concat/1
  sub_odd_imag/1(dout) -> Concat/2
  sub_even_imag/1(dout) -> Concat/3
  add_odd_real/1(dout) -> Concat/4
  Concat/1 -> bus_scale/1(din)
  bus_scale/1(dout) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/3(out2) -> ri_to_c/2
  bus_expand/1(msb_out4) -> ri_to_c/1
  bus_expand/2(out3) -> ri_to_c1/2
  bus_expand/4(lsb_out1) -> ri_to_c1/1
  ri_to_c/1 -> munge_even/1(din)
  ri_to_c1/1 -> munge_odd/1(din)
  munge_even/1(dout) -> even/1
  munge_odd/1(dout) -> odd/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert1 ==
  a : Inport
  b : Inport  Port=2
  Concat : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  add_even_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=0, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  add_odd_real : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=0, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=[19 19 19 19 19 19 19 19 19 19 19 19], bin_pt_in=bin_pt_in+1, cmplx=off, n_bits_out=18, bin_pt_out=bin_pt_in, quantization=2, overflow=0, csp_latency=conv_latency, of=off, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=4, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand_a : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand_b : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_scale : Subsystem  AncestorBlock=casper_library_bus/bus_scale  mask(bus_scale){n_bits_in=[19 19 19 19 19 19 19 19 19 19 19 19], bin_pt_in=bin_pt_in, type_in=1, cmplx=off, scale_factor=-1, misc=off}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; type_in "input types"; cmplx "input complex"; scale_factor "scale factor (2^?)"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_scale_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'type_in', type_in, ...
      |     'cmplx', cmplx, ...
      |     'scale_factor', scale_factor, ...
      |     'misc', misc);
  munge_a : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_b : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_even : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_odd : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  ri_to_c : casper_library_misc/ri_to_c
  ri_to_c1 : casper_library_misc/ri_to_c
  sub_even_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=1, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  sub_odd_imag : Subsystem  AncestorBlock=casper_library_bus/bus_addsub  mask(bus_addsub){opmode=1, n_bits_a=[18 18 18], bin_pt_a=17, type_a=1, n_bits_b=[18 18 18], bin_pt_b=17, type_b=1, cmplx=off, misc=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_bits_out=[19 19 19], bin_pt_out=17, type_out=1, quantization=0, overflow=0, add_implementation=fabric core, csp_latency=add_latency, pipeline_en=off, pipeline_latency=0}
      mask prompts: opmode "mode (Addition=0, Subtraction=1)"; n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx "complex"; misc "misc support"; async "asynchronous operation"; floating_point "floating point"; exp_width "exponent width"; frac_width "fraction width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; add_implementation "adder implementation"; csp_latency "latency"; pipeline_en "pipeline enable"; pipeline_latency "pipeline latency"
      mask help: Add/subtract components of two busses
      mask init:
      | bus_addsub_init(gcb, ...
      |     'opmode', opmode, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...
      |     'type_out', type_out, ...
      |     'overflow', overflow, ...        
      |     'quantization', quantization, ...
      |     'add_implementation', add_implementation, ...
      |     'csp_latency', csp_latency, ...
      |     'pipeline_en', pipeline_en, ...
      |     'pipeline_latency', pipeline_latency,...
      |     'cmplx', cmplx, ...
      |     'misc', misc, ...
      |     'async', async);
  even : Outport
  odd : Outport  Port=2
  wires:
  b/1 -> munge_b/1(din)
  a/1 -> munge_a/1(din)
  munge_a/1(dout) -> bus_expand_a/1(bus_in)
  munge_b/1(dout) -> bus_expand_b/1(bus_in)
  bus_expand_a/1(msb_out2) -> add_even_real/1(a), sub_odd_imag/2(b)
  bus_expand_b/1(msb_out2) -> add_even_real/2(b), sub_odd_imag/1(a)
  bus_expand_a/2(lsb_out1) -> sub_even_imag/1(a), add_odd_real/1(a)
  bus_expand_b/2(lsb_out1) -> sub_even_imag/2(b), add_odd_real/2(b)
  add_even_real/1(dout) -> Concat/1
  sub_odd_imag/1(dout) -> Concat/2
  sub_even_imag/1(dout) -> Concat/3
  add_odd_real/1(dout) -> Concat/4
  Concat/1 -> bus_scale/1(din)
  bus_scale/1(dout) -> bus_convert/1(din)
  bus_convert/1(dout) -> bus_expand/1(bus_in)
  bus_expand/3(out2) -> ri_to_c/2
  bus_expand/1(msb_out4) -> ri_to_c/1
  bus_expand/2(out3) -> ri_to_c1/2
  bus_expand/4(lsb_out1) -> ri_to_c1/1
  ri_to_c/1 -> munge_even/1(din)
  ri_to_c1/1 -> munge_odd/1(din)
  munge_even/1(dout) -> even/1
  munge_odd/1(dout) -> odd/1
