simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 131 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult1/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult1/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult2/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult2/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult3/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_8/butterfly_direct/twiddle/bus_mult/mult3/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult1/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult1/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult2/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult2/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult3/a_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_9/butterfly_direct/twiddle/bus_mult/mult3/b_replicate/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  concatenate : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
