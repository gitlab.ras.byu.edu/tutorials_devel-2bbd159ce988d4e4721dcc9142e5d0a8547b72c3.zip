simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 30 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_3 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1 2 3], StepPeriod=6, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,04961a6a,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_4 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1 2 3 4 5 6 7], StepPeriod=5, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,b5591290,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_5 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15], StepPeriod=4, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,eafdfd08,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_6 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31], StepPeriod=3, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,7a8c02d8,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_7 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63], StepPeriod=2, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1
