simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 7 of 131)

== system snap_tut_corr/pfb_fir_generic/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=25, n_bits_out=18, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[28 28 28 28 28 28 28 28 28 28 28 28], outputBinaryPt=[25 25 25 25 25 25 25 25 25 25 25 25], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(in)
  debus/2(out11) -> conv2/1(in)
  debus/3(out10) -> conv3/1(in)
  debus/4(out9) -> conv4/1(in)
  debus/5(out8) -> conv5/1(in)
  debus/6(out7) -> conv6/1(in)
  debus/7(out6) -> conv7/1(in)
  debus/8(out5) -> conv8/1(in)
  debus/9(out4) -> conv9/1(in)
  debus/10(out3) -> conv10/1(in)
  debus/11(out2) -> conv11/1(in)
  debus/12(lsb_out1) -> conv12/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/pfb_fir_generic/bus_create ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  concatenate : xbsIndex_r4/Concat  num_inputs=12  dbl_ovrd=off  block_type=concat
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12

== system snap_tut_corr/pfb_fir_generic/bus_expand ==
  bus_in : Inport
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-198  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-180  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-162  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-144  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out12 : Outport
  out11 : Outport  Port=2
  out10 : Outport  Port=3
  out9 : Outport  Port=4
  out8 : Outport  Port=5
  out7 : Outport  Port=6
  out6 : Outport  Port=7
  out5 : Outport  Port=8
  out4 : Outport  Port=9
  out3 : Outport  Port=10
  out2 : Outport  Port=11
  lsb_out1 : Outport  Port=12
  wires:
  bus_in/1 -> slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> msb_out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/bus_scale ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[28 28 28 28 28 28 28 28 28 28 28 28], outputBinaryPt=[24 24 24 24 24 24 24 24 24 24 24 24], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  scale{1..12} (12 alike) : xbsIndex_r4/Scale  scale_factor=-1  dbl_ovrd=off  block_type=scale
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> scale1/1
  debus/2(out11) -> scale2/1
  debus/3(out10) -> scale3/1
  debus/4(out9) -> scale4/1
  debus/5(out8) -> scale5/1
  debus/6(out7) -> scale6/1
  debus/7(out6) -> scale7/1
  debus/8(out5) -> scale8/1
  debus/9(out4) -> scale9/1
  debus/10(out3) -> scale10/1
  debus/11(out2) -> scale11/1
  debus/12(lsb_out1) -> scale12/1
  scale1/1 -> bussify/1(in1)
  scale2/1 -> bussify/2(in2)
  scale3/1 -> bussify/3(in3)
  scale4/1 -> bussify/4(in4)
  scale5/1 -> bussify/5(in5)
  scale6/1 -> bussify/6(in6)
  scale7/1 -> bussify/7(in7)
  scale8/1 -> bussify/8(in8)
  scale9/1 -> bussify/9(in9)
  scale10/1 -> bussify/10(in10)
  scale11/1 -> bussify/11(in11)
  scale12/1 -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/pfb_fir_generic/coeff_munge ==
  din : Inport
  join : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=48}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], outputBinaryPt=[0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  reinterpret_out/1 -> dout/1
  din/1 -> reinterpret/1
  reinterpret/1 -> split/1(bus_in)
  join/1(bus_out) -> reinterpret_out/1
  split/13(out4) -> join/1(in1), join/2(in2), join/3(in3)
  split/14(out3) -> join/4(in4), join/5(in5), join/6(in6)
  split/15(out2) -> join/7(in7), join/8(in8), join/9(in9)
  split/16(lsb_out1) -> join/10(in10), join/11(in11), join/12(in12)
  split/9(out8) -> join/13(in13), join/14(in14), join/15(in15)
  split/10(out7) -> join/16(in16), join/17(in17), join/18(in18)
  split/11(out6) -> join/19(in19), join/20(in20), join/21(in21)
  split/12(out5) -> join/22(in22), join/23(in23), join/24(in24)
  split/5(out12) -> join/25(in25), join/26(in26), join/27(in27)
  split/6(out11) -> join/28(in28), join/29(in29), join/30(in30)
  split/7(out10) -> join/31(in31), join/32(in32), join/33(in33)
  split/8(out9) -> join/34(in34), join/35(in35), join/36(in36)
  split/1(msb_out16) -> join/37(in37), join/38(in38), join/39(in39)
  split/2(out15) -> join/40(in40), join/41(in41), join/42(in42)
  split/3(out14) -> join/43(in43), join/44(in44), join/45(in45)
  split/4(out13) -> join/46(in46), join/47(in47), join/48(in48)

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen ==
  sync : Inport
  din : Inport  Port=2
  a_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=18, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=8, outputWidth=18, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  concat : xbsIndex_r4/Concat  num_inputs=16  dbl_ovrd=off  block_type=concat
  const0 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=18  bin_pt=17  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  const1 : xbsIndex_r4/Constant  const=2.104e-17  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=18  bin_pt=17  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  d{0..15} (16 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dfirst : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  first : xbsIndex_r4/Relational  mode=a=b  op_type=Bool  en=off  latency=1  dbl_ovrd=off  block_type=relational
  inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  munge : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=8, div_size=[18 18 18 18 18 18 18 18], order=[4 7 6 5 0 3 2 1], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  reinterpret0 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  rom : Subsystem  AncestorBlock=casper_library_bus/bus_dual_port_ram  mask(bus_dual_port_ram){n_bits=[18 18 18 18 18 18 18 18], bin_pts=[17 17 17 17 17 17 17 17], init_vector=[pfb_coeff_gen_calc(11, 4, 'hamming', 2, 0, 1, 1, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 1, 1, 1, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 2, 1, 1, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 3, 1, 1, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 0, 1, 2, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 1, 1, 2, false)', pfb_coeff_gen_calc(11, 4, 'hamming', 2, 2, 1, 2, fa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, max_fanout=1, mem_type=Block RAM, bram_optimization=Area, async_a=off, async_b=off, b_to_a_ratio_bits=0, misc=off, bram_latency=1, fan_latency=1, addra_register=on, addra_implementation=core, dina_register=off, dina_implementation=behavioral, wea_register=off, wea_implementation=behavioral, ena_register=off, ena_implementation=core, addrb_register=on, addrb_implementation=core, dinb_register=off, dinb_implementation=behavioral, web_register=off, web_implementation=behavioral, enb_register=off, enb_implementation=core}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async_a "a asynchronous"; async_b "b asynchronous"; b_to_a_ratio_bits "b_to_a ratio bits"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addra_register "addra input register"; addra_implementation "addra register implementation"; dina_register "dina input register"; dina_implementation "dina register implementation"; wea_register "wea input register"; wea_implementation "wea register implementation"; ena_register "ena input register"; ena_implementation "ena register implementation"; addrb_register "addrb input register"; addrb_implementation "addrb register implementation"; dinb_register "dinb input register"; dinb_implementation "dinb register implementation"; web_register "web input register"; web_implementation "web register implementation"; enb_register "enb input register"; enb_implementation "enb register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_dual_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async_a', async_a, ...
      |     'async_b', async_b, ...
      |     'b_to_a_ratio_bits', b_to_a_ratio_bits, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addra_register', addra_register, ...
      |     'addra_implementation', addra_implementation, ...
      |     'dina_register', dina_register, ...
      |     'dina_implementation', dina_implementation, ...
      |     'wea_register', wea_register, ...
      |     'wea_implementation', wea_implementation, ...
      |     'ena_register', ena_register, ...
      |     'ena_implementation', ena_implementation, ...
      |     'addrb_register', addrb_register, ...
      |     'addrb_implementation', addrb_implementation, ...
      |     'dinb_register', dinb_register, ...
      |     'dinb_implementation', dinb_implementation, ...
      |     'web_register', web_register, ...
      |     'web_implementation', web_implementation, ...
      |     'enb_register', enb_register, ...
      |     'enb_implementation', enb_implementation);
  rom_din : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=144  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  rom_we : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=9  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_out : Outport
  dout : Outport  Port=2
  coeffs : Outport  Port=3
  wires:
  sync/1 -> sync_delay/1, counter/1
  sync_delay/1 -> sync_out/1
  din/1 -> din_delay/1
  din_delay/1 -> dout/1
  counter/1 -> inverter/1, rom/1(addra), first/2
  inverter/1 -> rom/4(addrb)
  rom_din/1 -> rom/2(dina), rom/5(dinb)
  rom_we/1 -> rom/3(wea), rom/6(web)
  zero/1 -> first/1
  first/1 -> dfirst/1
  rom/2(B) -> munge/1(din)
  rom/1(A) -> a_expand/1(bus_in)
  munge/1(dout) -> b_expand/1(bus_in)
  concat/1 -> coeffs/1
  a_expand/1(msb_out8) -> d0/1
  d0/1 -> concat/1
  a_expand/2(out7) -> d1/1
  d1/1 -> concat/2
  a_expand/3(out6) -> d2/1
  d2/1 -> concat/3
  a_expand/4(out5) -> d3/1
  d3/1 -> concat/4
  a_expand/5(out4) -> d4/1
  d4/1 -> concat/5
  a_expand/6(out3) -> d5/1
  d5/1 -> concat/6
  a_expand/7(out2) -> d6/1
  d6/1 -> concat/7
  a_expand/8(lsb_out1) -> d7/1
  d7/1 -> concat/8
  b_expand/1(msb_out8) -> d8/1
  const0/1 -> reinterpret0/1
  reinterpret0/1 -> mux0/3
  dfirst/1 -> mux0/1, mux1/1
  d8/1 -> mux0/2
  mux0/1 -> concat/9
  b_expand/2(out7) -> d9/1
  d9/1 -> concat/10
  b_expand/3(out6) -> d10/1
  d10/1 -> concat/11
  b_expand/4(out5) -> d11/1
  d11/1 -> concat/12
  b_expand/5(out4) -> d12/1
  const1/1 -> reinterpret1/1
  reinterpret1/1 -> mux1/3
  d12/1 -> mux1/2
  mux1/1 -> concat/13
  b_expand/6(out3) -> d13/1
  d13/1 -> concat/14
  b_expand/7(out2) -> d14/1
  d14/1 -> concat/15
  b_expand/8(lsb_out1) -> d15/1
  d15/1 -> concat/16

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps ==
  sync : Inport
  din : Inport  Port=2
  coeffs : Inport  Port=3
  always : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  arnold : Terminator
  bram_din : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  bus_adder_tree : Subsystem  AncestorBlock=casper_library_bus/bus_adder_tree  mask(bus_adder_tree){n_busses=4, n_bits=[26 26 26 26 26 26 26 26 26 26 26 26], num_float_vec=1, bin_pts=24, dtypes=1, misc=off, floating_point=off, float_type=single, frac_width=24, exp_width=8, add_latency=2, first_stage_hdl=on, adder_imp=Behavioral}
      mask prompts: n_busses "number of busses"; n_bits "bus component bit widths"; num_float_vec "number floating point vectors in bus"; bin_pts "bus component binary points"; dtypes "bus component data types"; misc "misc support"; floating_point "floating point"; float_type "float type"; frac_width "fraction width"; exp_width "exponent width"; add_latency "adder latency"; first_stage_hdl "implement first stage in of adders in behavioral HDL?"; adder_imp "adder implementation"
      mask help: Add components of multiple identical busses
      mask init:
      | bus_adder_tree_init(gcb, ...
      |     'n_busses', n_busses, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'dtypes', dtypes, ...
      |     'add_latency', add_latency, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...   
      |     'num_float_vec', num_float_vec, ...
      |     'first_stage_hdl', first_stage_hdl, ...
      |     'adder_imp', adder_imp, ...
      |     'misc', misc);
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult  mask(bus_mult){n_bits_a=[8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8], bin_pt_a=7, type_a=1, cmplx_a=off, n_bits_b=[18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18 18], bin_pt_b=17, type_b=1, cmplx_b=off, misc=off, floating_point=off, float_type=single, input_vec_a=1, input_vec_b=1, frac_width=24, exp_width=8, n_bits_out=n_bits_data+n_bits_coeff, bin_pt_out=n_bits_data-1+bin_pt_coeff, type_out=1, quantization=0, overflow=0, mult_latency=mult_latency, add_latency=0, conv_latency=0, max_fanout=1, fan_latency=0, multiplier_implementation=behavioral HDL, pipeline_cmult_en=off, pipeline_latency=0}
      mask prompts: n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; cmplx_a "a input complex"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx_b "b input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; input_vec_a "a input vector in bus"; input_vec_b "b input vector in bus"; frac_width "fraction width"; exp_width "exponent width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; mult_latency "multiplier latency"; add_latency "adder latency"; conv_latency "convert latency"; max_fanout "limit fanout to ?"; fan_latency "fanout register latency"; multiplier_implementation "multiplier implementation"; pipeline_cmult_en "pipeline complex mult"; pipeline_latency "pipeline latency"
      mask help: Multiply components of two busses
      mask init:
      | bus_mult_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'cmplx_a', cmplx_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'cmplx_b', cmplx_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'type_out', type_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'input_vec_a', input_vec_a, ...
      |     'input_vec_b', input_vec_b, ...
      |     'frac_width', frac_width, ...         
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'max_fanout', max_fanout, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'misc', misc);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  daddr : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dcoeffs : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  ddin : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=off  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  mult_din : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  never : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  sync_delay : casper_library_delays/sync_delay  DelayLen=(2^(pfb_size-n_inputs))*(n_taps-1)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,d7318e4b,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  tap_delays : Subsystem  AncestorBlock=casper_library_bus/bus_dual_port_ram  mask(bus_dual_port_ram){n_bits=[8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8 8], bin_pts=[0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0 0], init_vector=repmat(zeros(512, 1), 1, 36), max_fanout=1, mem_type=Block RAM, bram_optimization=Area, async_a=off, async_b=off, b_to_a_ratio_bits=0, misc=off, bram_latency=1, fan_latency=1, addra_register=on, addra_implementation=core, dina_register=off, dina_implementation=behavioral, wea_register=off, wea_implementation=behavioral, ena_register=off, ena_implementation=behavioral, addrb_register=on, addrb_implementation=core, dinb_register=on, dinb_implementation=core, web_register=on, web_implementation=core, enb_register=off, enb_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async_a "a asynchronous"; async_b "b asynchronous"; b_to_a_ratio_bits "b_to_a ratio bits"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addra_register "addra input register"; addra_implementation "addra register implementation"; dina_register "dina input register"; dina_implementation "dina register implementation"; wea_register "wea input register"; wea_implementation "wea register implementation"; ena_register "ena input register"; ena_implementation "ena register implementation"; addrb_register "addrb input register"; addrb_implementation "addrb register implementation"; dinb_register "dinb input register"; dinb_implementation "dinb register implementation"; web_register "web input register"; web_implementation "web register implementation"; enb_register "enb input register"; enb_implementation "enb register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_dual_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async_a', async_a, ...
      |     'async_b', async_b, ...
      |     'b_to_a_ratio_bits', b_to_a_ratio_bits, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addra_register', addra_register, ...
      |     'addra_implementation', addra_implementation, ...
      |     'dina_register', dina_register, ...
      |     'dina_implementation', dina_implementation, ...
      |     'wea_register', wea_register, ...
      |     'wea_implementation', wea_implementation, ...
      |     'ena_register', ena_register, ...
      |     'ena_implementation', ena_implementation, ...
      |     'addrb_register', addrb_register, ...
      |     'addrb_implementation', addrb_implementation, ...
      |     'dinb_register', dinb_register, ...
      |     'dinb_implementation', dinb_implementation, ...
      |     'web_register', web_register, ...
      |     'web_implementation', web_implementation, ...
      |     'enb_register', enb_register, ...
      |     'enb_implementation', enb_implementation);
  tap_split : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=4, outputWidth=312, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  youngest : xbsIndex_r4/Slice  nbits=(1*n_bits_data)*(n_taps-2)*(2^n_inputs)*n_streams  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  dsync0/1 -> dsync1/1
  dsync1/1 -> dsync2/1
  dsync2/1 -> sync_out/1
  din/1 -> ddin/1
  coeffs/1 -> dcoeffs/1
  sync/1 -> sync_delay/1, counter/1
  sync_delay/1 -> dsync0/1
  ddin/1 -> bram_din/1, mult_din/1
  youngest/1 -> bram_din/2
  counter/1 -> daddr/1, tap_delays/1(addra)
  bram_din/1 -> tap_delays/2(dina), tap_delays/5(dinb)
  never/1 -> tap_delays/3(wea)
  daddr/1 -> tap_delays/4(addrb)
  always/1 -> tap_delays/6(web)
  tap_delays/2(B) -> arnold/1
  tap_delays/1(A) -> mult_din/2, youngest/1
  mult_din/1 -> bus_mult/1(a)
  dcoeffs/1 -> bus_mult/2(b)
  bus_mult/1(a*b) -> tap_split/1(bus_in)
  tap_split/1(msb_out4) -> bus_adder_tree/1(d0)
  tap_split/2(out3) -> bus_adder_tree/2(d1)
  tap_split/3(out2) -> bus_adder_tree/3(d2)
  tap_split/4(lsb_out1) -> bus_adder_tree/4(d3)
  bus_adder_tree/1(out) -> dout/1
