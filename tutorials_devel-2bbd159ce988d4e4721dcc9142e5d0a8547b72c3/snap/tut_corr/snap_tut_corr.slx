simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 43 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj1 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate  mask(bus_negate){n_bits_in=[18 18 18], bin_pt_in=17, cmplx=off, misc=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_vectors=1, overflow=0, csp_latency=0}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"
      mask help: Negate components of busses
      mask init:
      | bus_negate_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'n_vectors', n_vectors, ...
      |     'cmplx', cmplx, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc);
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj2 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate  mask(bus_negate){n_bits_in=[18 18 18], bin_pt_in=17, cmplx=off, misc=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_vectors=1, overflow=0, csp_latency=0}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"
      mask help: Negate components of busses
      mask init:
      | bus_negate_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'n_vectors', n_vectors, ...
      |     'cmplx', cmplx, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc);
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/complex_conj3 ==
  z : Inport
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=54, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  imag_negate : Subsystem  AncestorBlock=casper_library_bus/bus_negate  mask(bus_negate){n_bits_in=[18 18 18], bin_pt_in=17, cmplx=off, misc=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, n_vectors=1, overflow=0, csp_latency=0}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"
      mask help: Negate components of busses
      mask init:
      | bus_negate_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'n_vectors', n_vectors, ...
      |     'cmplx', cmplx, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc);
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 2 4 1 3 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=6, div_size=[18 18 18 18 18 18], order=[0 3 1 4 2 5], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  real_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  z* : Outport
  wires:
  z/1 -> munge_in/1(din)
  munge_in/1(dout) -> bus_expand/1(bus_in)
  bus_expand/1(msb_out2) -> real_delay/1
  bus_expand/2(lsb_out1) -> imag_negate/1(din)
  real_delay/1 -> bus_create/1(in1)
  imag_negate/1(dout) -> bus_create/2(in2)
  bus_create/1(bus_out) -> munge_out/1(din)
  munge_out/1(dout) -> z*/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux0 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out3) -> mux0/1
  expand0/1(msb_out3) -> mux0/2
  expand1/1(msb_out3) -> mux0/3
  sel_expand/2(out2) -> mux1/1
  expand0/2(out2) -> mux1/2
  expand1/2(out2) -> mux1/3
  sel_expand/3(lsb_out1) -> mux2/1
  expand0/3(lsb_out1) -> mux2/2
  expand1/3(lsb_out1) -> mux2/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux1 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out3) -> mux0/1
  expand0/1(msb_out3) -> mux0/2
  expand1/1(msb_out3) -> mux0/3
  sel_expand/2(out2) -> mux1/1
  expand0/2(out2) -> mux1/2
  expand1/2(out2) -> mux1/3
  sel_expand/3(lsb_out1) -> mux2/1
  expand0/3(lsb_out1) -> mux2/2
  expand1/3(lsb_out1) -> mux2/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux2 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out3) -> mux0/1
  expand0/1(msb_out3) -> mux0/2
  expand1/1(msb_out3) -> mux0/3
  sel_expand/2(out2) -> mux1/1
  expand0/2(out2) -> mux1/2
  expand1/2(out2) -> mux1/3
  sel_expand/3(lsb_out1) -> mux2/1
  expand0/3(lsb_out1) -> mux2/2
  expand1/3(lsb_out1) -> mux2/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/dmux3 ==
  sel : Inport
  d0 : Inport  Port=2
  d1 : Inport  Port=3
  d_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  expand0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36], outputBinaryPt=[0  0  0], outputArithmeticType=[0  0  0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux2 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  sel_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=1, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  out : Outport
  wires:
  sel/1 -> sel_expand/1(bus_in)
  d0/1 -> expand0/1(bus_in)
  d1/1 -> expand1/1(bus_in)
  sel_expand/1(msb_out3) -> mux0/1
  expand0/1(msb_out3) -> mux0/2
  expand1/1(msb_out3) -> mux0/3
  sel_expand/2(out2) -> mux1/1
  expand0/2(out2) -> mux1/2
  expand1/2(out2) -> mux1/3
  sel_expand/3(lsb_out1) -> mux2/1
  expand0/3(lsb_out1) -> mux2/2
  expand1/3(lsb_out1) -> mux2/3
  mux0/1 -> d_bussify/1(in1)
  mux1/1 -> d_bussify/2(in2)
  mux2/1 -> d_bussify/3(in3)
  d_bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1
  din0_0/1 -> din1_0/1, din1_1/1, din1_2/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate1 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1
  din0_0/1 -> din1_0/1, din1_1/1, din1_2/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate2 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1
  din0_0/1 -> din1_0/1, din1_1/1, din1_2/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/mirror_spectrum/sel_replicate3 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din1_2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1
  din0_0/1 -> din1_0/1, din1_1/1, din1_2/1
  din1_0/1 -> bussify/1(in1)
  din1_1/1 -> bussify/2(in2)
  din1_2/1 -> bussify/3(in3)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/addr_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_lsb_out1 : Outport
  wires:
  bus_in/1 -> slice1/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> msb_lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_even/addr_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=1}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  out : Outport
  wires:
  in/1 -> bussify/1(in1)
  bussify/1(bus_out) -> out/1
