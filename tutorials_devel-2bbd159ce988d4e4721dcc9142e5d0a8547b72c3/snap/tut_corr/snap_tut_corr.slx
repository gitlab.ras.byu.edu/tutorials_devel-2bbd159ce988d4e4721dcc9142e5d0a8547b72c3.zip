simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 6 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x ==
  sync : Inport
  shift : Inport  Port=2
  pol0_in : Inport  Port=3
  pol1_in : Inport  Port=4
  pol2_in : Inport  Port=5
  pol3_in : Inport  Port=6
  pol4_in : Inport  Port=7
  pol5_in : Inport  Port=8
  pol6_in : Inport  Port=9
  pol7_in : Inport  Port=10
  pol8_in : Inport  Port=11
  pol9_in : Inport  Port=12
  pol10_in : Inport  Port=13
  pol11_in : Inport  Port=14
  bi_real_unscr_4x : Subsystem  AncestorBlock=casper_library_ffts_internal/bi_real_unscr_4x  mask(bi_real_unscr_4x){n_inputs=3, FFTSize=9, n_bits=18, bin_pt=17, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, conv_latency=conv_latency, bram_latency=bram_latency, bram_map=on, bram_delays=on, dsp48_adders=off, async=off}
      mask prompts: n_inputs "Number simultaneous inputs (2*?)"; FFTSize "Size of FFT (2^?):"; n_bits "Sample Bit Width"; bin_pt "Sample binary point"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; conv_latency "Convert Latency"; bram_latency "BRAM Latency"; bram_map "Use BlockRAM for Map"; bram_delays "Use BlockRAM for Delays"; dsp48_adders "Use DSP48s for adders"; async "Asynchonrous operation"
      mask help: FFT internal block.
      mask init:
      | bi_real_unscr_4x_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize, ...
      |     'n_bits', n_bits, ...
      |     'bin_pt', bin_pt, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'bram_latency', bram_latency, ...
      |     'bram_map', bram_map, ...
      |     'bram_delays', bram_delays, ...
      |     'dsp48_adders', dsp48_adders, ...
      |     'async', async);
  biplex_core : Subsystem  AncestorBlock=casper_library_ffts/biplex_core  mask(biplex_core){n_inputs=3, FFTSize=9, input_bit_width=18, bin_pt_in=17, coeff_bit_width=18, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, delays_bit_limit=7, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, max_fanout=8, mult_spec=[2 2 2 2 2 2 2 2 2], bitgrowth=off, max_bits=19, hardcode_shifts=off, shift_schedule=[1 1 1 1 1 1 1 1 1], dsp48_adders=off, async=off}
      mask prompts: n_inputs "Number inputs (2*?)"; FFTSize "Size of FFT: (2^? pts)"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; coeff_bit_width "Coefficient Bit Width"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Interface Pipeline Latency"; mult_pipe_latency "CMult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; delays_bit_limit "Number bits above which to implent stage's delays in BRAM (2^? bits)"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; max_fanout "Maximum fanout"; mult_spec "Multiplier impl. (0=core, 1=embedded, 2=behavioural) (left=1st stage, or just one value)"; bitgrowth "Bit growth instead of shift"; max_bits "Maximum number of bits"; hardcode_shifts "Hardcode shift schedule"; shift_schedule "Shift schedule"; dsp48_adders "Use DSP48s for adders"; async "Asynchronous operation"
      mask help: FFT internal block.
      mask init:
      | biplex_core_init(gcb, ...
      |     'n_inputs', n_inputs, ...
      |     'FFTSize', FFTSize,...
      |     'input_bit_width', input_bit_width,...
      |     'bin_pt_in', bin_pt_in,...
      |     'coeff_bit_width', coeff_bit_width,...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...       
      |     'async', async, ...
      |     'add_latency', add_latency,...
      |     'mult_latency', mult_latency,...
      |     'bram_latency', bram_latency,...
      |     'conv_latency', conv_latency, ...
      |     'add_pipe_latency', add_pipe_latency, ...
      |     'mult_pipe_latency', mult_pipe_latency, ...        
      |     'quantization', quantization,...
      |     'overflow', overflow,...
      |     'delays_bit_limit', delays_bit_limit, ...
      |     'coeffs_bit_limit', coeffs_bit_limit, ...
      |     'coeff_sharing', coeff_sharing, ...
      |     'coeff_decimation', coeff_decimation, ...
      |     'max_fanout', max_fanout, ...
      |     'mult_spec', mult_spec, ...
      |     'bitgrowth', bitgrowth, ...
      |     'max_bits', max_bits, ...
      |     'hardcode_shifts', hardcode_shifts, ...
      |     'shift_schedule', shift_schedule, ...
      |     'dsp48_adders', dsp48_adders);
  even_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  odd_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  pol0_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  pol1_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  pol2_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  pol3_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  ri_to_c0 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  ri_to_c1 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  ri_to_c2 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  ri_to_c3 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  ri_to_c4 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  ri_to_c5 : Subsystem  AncestorBlock=casper_library_misc/ri_to_c  mask(ri_to_c){}
      mask help: Concatenates real and imaginary inputs into a complex output. Useful for simplifying interconnects. See also: Complex to Real-Imag (c_to_ri)
  sync_out : Outport
  pol0_out : Outport  Port=2
  pol1_out : Outport  Port=3
  pol2_out : Outport  Port=4
  pol3_out : Outport  Port=5
  pol4_out : Outport  Port=6
  pol5_out : Outport  Port=7
  pol6_out : Outport  Port=8
  pol7_out : Outport  Port=9
  pol8_out : Outport  Port=10
  pol9_out : Outport  Port=11
  pol10_out : Outport  Port=12
  pol11_out : Outport  Port=13
  of : Outport  Port=14
  wires:
  pol0_debus/1(msb_out3) -> pol0_out/1
  pol0_in/1 -> ri_to_c0/1(re)
  pol1_in/1 -> ri_to_c0/2(im)
  ri_to_c0/1(c) -> even_bussify/1(in1)
  pol1_debus/1(msb_out3) -> pol1_out/1
  pol2_debus/1(msb_out3) -> pol2_out/1
  pol2_in/1 -> ri_to_c1/1(re)
  pol3_in/1 -> ri_to_c1/2(im)
  ri_to_c1/1(c) -> odd_bussify/1(in1)
  pol3_debus/1(msb_out3) -> pol3_out/1
  pol0_debus/2(out2) -> pol4_out/1
  pol4_in/1 -> ri_to_c2/1(re)
  pol5_in/1 -> ri_to_c2/2(im)
  ri_to_c2/1(c) -> even_bussify/2(in2)
  pol1_debus/2(out2) -> pol5_out/1
  pol2_debus/2(out2) -> pol6_out/1
  pol6_in/1 -> ri_to_c3/1(re)
  pol7_in/1 -> ri_to_c3/2(im)
  ri_to_c3/1(c) -> odd_bussify/2(in2)
  pol3_debus/2(out2) -> pol7_out/1
  pol0_debus/3(lsb_out1) -> pol8_out/1
  pol8_in/1 -> ri_to_c4/1(re)
  pol9_in/1 -> ri_to_c4/2(im)
  ri_to_c4/1(c) -> even_bussify/3(in3)
  pol1_debus/3(lsb_out1) -> pol9_out/1
  pol2_debus/3(lsb_out1) -> pol10_out/1
  pol10_in/1 -> ri_to_c5/1(re)
  pol11_in/1 -> ri_to_c5/2(im)
  ri_to_c5/1(c) -> odd_bussify/3(in3)
  pol3_debus/3(lsb_out1) -> pol11_out/1
  sync/1 -> biplex_core/1(sync)
  shift/1 -> biplex_core/2(shift)
  even_bussify/1(bus_out) -> biplex_core/3(pol1)
  odd_bussify/1(bus_out) -> biplex_core/4(pol2)
  biplex_core/4(of) -> of/1
  biplex_core/1(sync_out) -> bi_real_unscr_4x/1(sync)
  biplex_core/2(out1) -> bi_real_unscr_4x/2(even)
  biplex_core/3(out2) -> bi_real_unscr_4x/3(odd)
  bi_real_unscr_4x/1(sync_out) -> sync_out/1
  bi_real_unscr_4x/2(pol1_out) -> pol0_debus/1(bus_in)
  bi_real_unscr_4x/3(pol2_out) -> pol1_debus/1(bus_in)
  bi_real_unscr_4x/4(pol3_out) -> pol2_debus/1(bus_in)
  bi_real_unscr_4x/5(pol4_out) -> pol3_debus/1(bus_in)

== system snap_tut_corr/fft_wideband_real/fft_direct ==
  sync : Inport
  shift : Inport  Port=2
  in00 : Inport  Port=3
  in01 : Inport  Port=4
  in02 : Inport  Port=5
  in03 : Inport  Port=6
  in10 : Inport  Port=7
  in11 : Inport  Port=8
  in12 : Inport  Port=9
  in13 : Inport  Port=10
  in20 : Inport  Port=11
  in21 : Inport  Port=12
  in22 : Inport  Port=13
  in23 : Inport  Port=14
  abus : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  adebus0_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=[108 108], outputBinaryPt=[0 0], outputArithmeticType=[0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  adebus1_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  adebus1_1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bbus : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bdebus0_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=[108 108], outputBinaryPt=[0 0], outputArithmeticType=[0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bdebus1_0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bdebus1_1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  butterfly0_0 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=6, biplex=off, FFTSize=11, Coeffs=[ 0 256 128 384 64 320 192 448 32 288 160 416 96 352 224 480 16 272 144 400 80 336 208 464 48 304 176 432 112 368 240 496 8 264 136 392 72 328 200 456 40 296 168 424 104 360 232 488 24 280 152 408 88 344 216 472 56 312 184 440 120 376 248 504 4 260 132 388 68 324 196 452 36 292 164 420 100 356 228 484 20 276 148 404 84 340 212 468 52 308 180 436 116 372 244 500 12 268 140 396 76 332 204 460 44 300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, StepPeriod=0, coeff_bit_width=18, input_bit_width=18, bin_pt_in=17, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  butterfly1_0 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=off, FFTSize=11, Coeffs=[ 0 512 256 768 128 640 384 896 64 576 320 832 192 704 448 960 32 544 288 800 160 672 416 928 96 608 352 864 224 736 480 992 16 528 272 784 144 656 400 912 80 592 336 848 208 720 464 976 48 560 304 816 176 688 432 944 112 624 368 880 240 752 496 1008 8 520 264 776 136 648 392 904 72 584 328 840 200 712 456 968 40 552 296 808 168 680 424 936 104 616 360 872 232 744 488 1000 24 536 280 792 152 664 4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, StepPeriod=0, coeff_bit_width=18, input_bit_width=18, bin_pt_in=17, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  butterfly1_1 : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=off, FFTSize=11, Coeffs=[ 1 513 257 769 129 641 385 897 65 577 321 833 193 705 449 961 33 545 289 801 161 673 417 929 97 609 353 865 225 737 481 993 17 529 273 785 145 657 401 913 81 593 337 849 209 721 465 977 49 561 305 817 177 689 433 945 113 625 369 881 241 753 497 1009 9 521 265 777 137 649 393 905 73 585 329 841 201 713 457 969 41 553 297 809 169 681 425 937 105 617 361 873 233 745 489 1001 25 537 281 793 153 665 4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, StepPeriod=0, coeff_bit_width=18, input_bit_width=18, bin_pt_in=17, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=1, mult_latency=3, bram_latency=3, conv_latency=1, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=7, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=8, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  combine : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  of_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  of_1 : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  of_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=3, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  of_or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  synct1 : Terminator
  sync_out : Outport
  out00 : Outport  Port=2
  out01 : Outport  Port=3
  out02 : Outport  Port=4
  out03 : Outport  Port=5
  out10 : Outport  Port=6
  out11 : Outport  Port=7
  out12 : Outport  Port=8
  out13 : Outport  Port=9
  out20 : Outport  Port=10
  out21 : Outport  Port=11
  out22 : Outport  Port=12
  out23 : Outport  Port=13
  of : Outport  Port=14
  wires:
  in00/1 -> abus/1(in1)
  adebus1_0/1(msb_out3) -> out00/1
  in01/1 -> abus/4(in4)
  adebus1_1/1(msb_out3) -> out01/1
  in02/1 -> bbus/1(in1)
  bdebus1_0/1(msb_out3) -> out02/1
  in03/1 -> bbus/4(in4)
  bdebus1_1/1(msb_out3) -> out03/1
  in10/1 -> abus/2(in2)
  adebus1_0/2(out2) -> out10/1
  in11/1 -> abus/5(in5)
  adebus1_1/2(out2) -> out11/1
  in12/1 -> bbus/2(in2)
  bdebus1_0/2(out2) -> out12/1
  in13/1 -> bbus/5(in5)
  bdebus1_1/2(out2) -> out13/1
  in20/1 -> abus/3(in3)
  adebus1_0/3(lsb_out1) -> out20/1
  in21/1 -> abus/6(in6)
  adebus1_1/3(lsb_out1) -> out21/1
  in22/1 -> bbus/3(in3)
  bdebus1_0/3(lsb_out1) -> out22/1
  in23/1 -> bbus/6(in6)
  bdebus1_1/3(lsb_out1) -> out23/1
  of_or/1 -> of_expand/1(bus_in)
  of_expand/1(msb_out2) -> combine/1
  of_expand/2(lsb_out1) -> combine/2
  combine/1 -> of/1
  shift/1 -> slice0/1, slice1/1
  of_0/1 -> of_or/1
  sync/1 -> butterfly0_0/3(sync_in)
  slice0/1 -> butterfly0_0/4(shift)
  abus/1(bus_out) -> butterfly0_0/1(a)
  bbus/1(bus_out) -> butterfly0_0/2(b)
  butterfly0_0/3(of) -> of_0/1
  butterfly0_0/1(a+bw) -> adebus0_0/1(bus_in)
  butterfly0_0/2(a-bw) -> bdebus0_0/1(bus_in)
  of_1/1 -> of_or/2
  butterfly0_0/4(sync_out) -> butterfly1_0/3(sync_in), butterfly1_1/3(sync_in)
  butterfly1_0/4(sync_out) -> sync_out/1
  slice1/1 -> butterfly1_0/4(shift), butterfly1_1/4(shift)
  adebus0_0/1(msb_out2) -> butterfly1_0/1(a)
  adebus0_0/2(lsb_out1) -> butterfly1_0/2(b)
  butterfly1_0/3(of) -> of_1/1
  butterfly1_1/4(sync_out) -> synct1/1
  bdebus0_0/1(msb_out2) -> butterfly1_1/1(a)
  bdebus0_0/2(lsb_out1) -> butterfly1_1/2(b)
  butterfly1_1/3(of) -> of_1/2
  butterfly1_0/1(a+bw) -> adebus1_0/1(bus_in)
  butterfly1_0/2(a-bw) -> bdebus1_0/1(bus_in)
  butterfly1_1/1(a+bw) -> adebus1_1/1(bus_in)
  butterfly1_1/2(a-bw) -> bdebus1_1/1(bus_in)

== system snap_tut_corr/fft_wideband_real/fft_direct_sync_delay ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler ==
  sync : Inport
  in00 : Inport  Port=2
  in01 : Inport  Port=3
  in10 : Inport  Port=4
  in11 : Inport  Port=5
  in20 : Inport  Port=6
  in21 : Inport  Port=7
  bus0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  debus0 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  debus1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=3, outputWidth=[36 36 36], outputBinaryPt=[0 0 0], outputArithmeticType=[0 0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  en : xbsIndex_r4/Constant  const=1.0  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=16  bin_pt=14  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  reorder : Subsystem  AncestorBlock=casper_library_reorder/reorder  mask(reorder){map=[0 2 4 6 8 10 12 14 16 18 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 50 52 54 56 58 60 62 64 66 68 70 72 74 76 78 80 82 84 86 88 90 92 94 96 98 100 102 104 106 108 110 112 114 116 118 120 122 124 126 128 130 132 134 136 138 140 142 144 146 148 150 152 154 156 158 160 162 164 166 168 170 172 174 176 178 180 182 184 186 188 190 192 194 196 198 200 202 204 206 208 210 212 214 216 218 220 222 224 22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, n_bits=108, n_inputs=2, bram_latency=3, map_latency=2, fanout_latency=2, double_buffer=0, bram_map=on, software_controlled=off}
      mask prompts: map "Output Order:"; n_bits "Data width in"; n_inputs "Number of inputs"; bram_latency "BRAM Latency"; map_latency "Map Latency"; fanout_latency "Fanout latency"; double_buffer "Double Buffer"; bram_map "Use BlockRAM for Map"; software_controlled "Use runtime software control"
      mask init:
      | reorder_init(gcb, ...
      |     'map', map, ...
      |     'n_bits', n_bits, ...
      |     'n_inputs', n_inputs, ...
      |     'bram_latency', bram_latency, ...
      |     'map_latency', map_latency, ...
      |     'fanout_latency', fanout_latency, ...
      |     'double_buffer', double_buffer, ...
      |     'bram_map', bram_map, ...
      |     'software_controlled', software_controlled);
  square_transposer : Subsystem  AncestorBlock=casper_library_reorder/square_transposer  mask(square_transposer){n_inputs=1, async=off}
      mask prompts: n_inputs "Number of inputs (2^?):"; async "Aynchronus operation"
      mask init:
      | square_transposer_init(gcb,...
      |     'n_inputs', n_inputs, ...
      |     'async', async);
  ten : Terminator
  sync_out : Outport
  out00 : Outport  Port=2
  out01 : Outport  Port=3
  out10 : Outport  Port=4
  out11 : Outport  Port=5
  out20 : Outport  Port=6
  out21 : Outport  Port=7
  wires:
  in00/1 -> bus0/1(in1)
  debus0/1(msb_out3) -> out00/1
  in01/1 -> bus1/1(in1)
  debus1/1(msb_out3) -> out01/1
  in10/1 -> bus0/2(in2)
  debus0/2(out2) -> out10/1
  in11/1 -> bus1/2(in2)
  debus1/2(out2) -> out11/1
  in20/1 -> bus0/3(in3)
  debus0/3(lsb_out1) -> out20/1
  in21/1 -> bus1/3(in3)
  debus1/3(lsb_out1) -> out21/1
  sync/1 -> square_transposer/1(sync)
  square_transposer/1(sync_out) -> reorder/1(sync)
  reorder/1(sync_out) -> sync_out/1
  en/1 -> reorder/2(en)
  reorder/2(valid) -> ten/1
  bus0/1(bus_out) -> square_transposer/2(in0)
  square_transposer/2(out0) -> reorder/3(din0)
  reorder/3(dout0) -> debus0/1(bus_in)
  bus1/1(bus_out) -> square_transposer/3(in1)
  square_transposer/3(out1) -> reorder/4(din1)
  reorder/4(dout1) -> debus1/1(bus_in)

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol0 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol11 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol3 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol4 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol7 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol8 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_4x_pol9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/in_del_sync_4x ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/negedge_delay1/negedge ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2
