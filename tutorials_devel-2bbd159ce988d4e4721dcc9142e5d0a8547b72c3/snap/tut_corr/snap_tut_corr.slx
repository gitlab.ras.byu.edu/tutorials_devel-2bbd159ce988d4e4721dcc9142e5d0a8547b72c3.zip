simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 29 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/reorder_out ==
  sync : Inport
  en : Inport  Port=2
  din0 : Inport  Port=3
  din1 : Inport  Port=4
  din2 : Inport  Port=5
  din3 : Inport  Port=6
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice2 : xbsIndex_r4/Slice  nbits=8  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  addr_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=4, outputWidth=8, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addr_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=4, csp_latency=2, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  buf0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  buf1 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  buf2 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  buf3 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[[repmat(64, 1, 1)], 44], bin_pts=[zeros(1, 2)], init_vector=[zeros(256,2)], max_fanout=1, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=1, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=core, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  delay_d0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_din{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_map1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_sel : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_valid : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  delay_we2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  map1 : xbsIndex_r4/ROM  depth=256  initVector=map  distributed_mem=Block RAM  rst=off  init_reg=0  en=off  latency=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=8  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  optimize=Speed  use_rpm=on  dbl_ovrd=off  block_type=sprom
  or : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  post_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  pre_sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_delay_en : casper_library_delays/sync_delay_en  DelayLen=256
      link override Constant2: sg_icon_stat=40,16,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 40 40 0 0 ],[0 0 16 16 0 ],[0.77 0.82 0.91 ]); plot([0 40 40 0 0 ],[0 0 16 16 0 ]); patch([15.55 18.44 20.44 22.44 24.44 20.44 17.55 15.55 ],[10.22 10.22 12.22 10.22 12.22 12.22 12.22 10.22 ],[1 1 1 ]); patch([17.55 20.44 18.44 15.55 17.55 ],[8.22 8.22 10.22 10.22 8.22 ],[0.931 0.946 0.973 ]); patch([15.55 18.44 20.44 17.55 15.55 ],[6.22 6.22 8.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
  we_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=4, outputWidth=1, outputBinaryPt=0, outputArithmeticType=2, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  we_replicate : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=4, csp_latency=2, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  sync_out : Outport
  valid : Outport  Port=2
  dout0 : Outport  Port=3
  dout1 : Outport  Port=4
  dout2 : Outport  Port=5
  dout3 : Outport  Port=6
  wires:
  en/1 -> delay_we0/1, delay_we1/1, delay_we2/1, Counter/2
  delay_we1/1 -> delay_valid/1
  delay_valid/1 -> valid/1
  delay_we2/1 -> we_replicate/1(in)
  we_replicate/1(out) -> we_expand/1(bus_in)
  sync/1 -> pre_sync_delay/1, Counter/1
  delay_we0/1 -> or/2
  pre_sync_delay/1 -> or/1, sync_delay_en/1
  or/1 -> sync_delay_en/2
  sync_delay_en/1 -> post_sync_delay/1
  post_sync_delay/1 -> sync_out/1
  din0/1 -> delay_din0/1
  din1/1 -> delay_din1/1
  din2/1 -> delay_din2/1
  din3/1 -> delay_din3/1
  Counter/1 -> Slice2/1, Slice1/1
  Slice2/1 -> delay_d0/1, map1/1
  addr_replicate/1(out) -> addr_expand/1(bus_in)
  we_expand/1(msb_out4) -> buf0/3(we)
  addr_expand/1(msb_out4) -> buf0/1(addr)
  delay_din0/1 -> buf0/2(din)
  buf0/1(dout) -> dout0/1
  we_expand/2(out3) -> buf1/3(we)
  addr_expand/2(out3) -> buf1/1(addr)
  delay_din1/1 -> buf1/2(din)
  buf1/1(dout) -> dout1/1
  we_expand/3(out2) -> buf2/3(we)
  addr_expand/3(out2) -> buf2/1(addr)
  delay_din2/1 -> buf2/2(din)
  buf2/1(dout) -> dout2/1
  we_expand/4(lsb_out1) -> buf3/3(we)
  addr_expand/4(lsb_out1) -> buf3/1(addr)
  delay_din3/1 -> buf3/2(din)
  buf3/1(dout) -> dout3/1
  Slice1/1 -> delay_sel/1
  delay_sel/1 -> Mux/1
  delay_d0/1 -> Mux/2
  Mux/1 -> addr_replicate/1(in)
  map1/1 -> delay_map1/1
  delay_map1/1 -> Mux/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/sync_delay ==
  In : Inport
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant2 : xbsIndex_r4/Constant  const=DelayLen  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant3 : xbsIndex_r4/Constant  const=UseCounter  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Down  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=on  rst=off  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Logical : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Relational : xbsIndex_r4/Relational  mode=a=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  Relational1 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  warn period Logical0 : xbsReplacements_r4/Warning  period=1
  warn period Relational10 : xbsReplacements_r4/Warning  period=1
  Out : Outport
  wires:
  Mux/1 -> Out/1
  Constant3/1 -> Mux/1
  Relational/1 -> Mux/3
  Relational1/1 -> Logical/2
  Logical/1 -> Counter/3
  In/1 -> Mux/2, Logical/1, Counter/1
  Constant2/1 -> Counter/2
  Constant/1 -> Relational/1
  Constant1/1 -> Relational1/2
  Counter/1 -> Relational/2, Relational1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_1 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  addr0 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  addr1 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=8  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=0, StepPeriod=8, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[18 18 18 18 18 18], bin_pts=[17 17 17 17 17 17], init_vector=zeros(2^8, 6), max_fanout=8, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=2, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=behavioral, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_single_port_ram  mask(bus_single_port_ram){n_bits=[18 18 18 18 18 18], bin_pts=[17 17 17 17 17 17], init_vector=zeros(2^8, 6), max_fanout=8, mem_type=Block RAM, bram_optimization=Speed, async=off, misc=off, bram_latency=3, fan_latency=2, addr_register=on, addr_implementation=core, din_register=on, din_implementation=behavioral, we_register=on, we_implementation=behavioral, en_register=off, en_implementation=behavioral}
      mask prompts: n_bits "data word bit widths"; bin_pts "data word binary points"; init_vector "initial value vector"; max_fanout "limit fanout to ?"; mem_type "memory type"; bram_optimization "memory optimization"; async "asynchronous"; misc "misc support"; bram_latency "bram latency"; fan_latency "input register latency"; addr_register "addr input register"; addr_implementation "addr register implementation"; din_register "din input register"; din_implementation "din register implementation"; we_register "we input register"; we_implementation "we register implementation"; en_register "en input register"; en_implementation "en register implementation"
      mask help: RAM for a bus allowing fanout control
      mask init:
      | bus_single_port_ram_init(gcb, ...
      |     'n_bits', n_bits, ...
      |     'bin_pts', bin_pts, ...
      |     'init_vector', init_vector, ...
      |     'max_fanout', max_fanout, ...
      |     'mem_type', mem_type, ...
      |     'bram_optimization', bram_optimization, ...
      |     'async', async, ...
      |     'misc', misc, ...
      |     'bram_latency', bram_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'addr_register', addr_register, ...
      |     'addr_implementation', addr_implementation, ...
      |     'din_register', din_register, ...
      |     'din_implementation', din_implementation, ...
      |     'we_register', we_register, ...
      |     'we_implementation', we_implementation, ...
      |     'en_register', en_register, ...
      |     'en_implementation', en_implementation);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=5  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=7  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=3  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,72f1e361,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  we0 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  we1 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  dsync0/1 -> dsync2/1
  dsync2/1 -> dsync1/1, counter/1
  din0/1 -> din1/1
  din1/1 -> mux1/2, mux0/3
  addr0/1 -> delay0/1(addr)
  we0/1 -> delay0/3(we)
  addr1/1 -> delay1/1(addr)
  we1/1 -> delay1/3(we)
  in2/1 -> delay0/2(din)
  mux1/1 -> delay1/2(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/biplex_core/fft_stage_2 ==
  in1 : Inport
  in2 : Inport  Port=2
  of_in : Inport  Port=3
  sync : Inport  Port=4
  shift : Inport  Port=5
  butterfly_direct : Subsystem  AncestorBlock=casper_library_ffts/butterfly_direct  mask(butterfly_direct){n_inputs=3, biplex=on, FFTSize=FFTSize, Coeffs=[0 1], StepPeriod=7, coeff_bit_width=coeff_bit_width, input_bit_width=input_bit_width, bin_pt_in=bin_pt_in, downshift=off, async=off, floating_point=off, float_type=single, exp_width=8, frac_width=24, add_latency=add_latency, mult_latency=mult_latency, bram_latency=bram_latency, conv_latency=conv_latency, add_pipe_latency=0, mult_pipe_latency=0, quantization=Round  (unbiased: Even Values), overflow=Wrap, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=1, n_bits_rotation=25, max_fanout=max_fanout, use_hdl=on, use_embedded=off, bitgrowth=off, hardcode_shifts=off, dsp48_adders=off}
      mask prompts: n_inputs "number inputs"; biplex "Used in biplex FFT"; FFTSize "Size of FFT: (2^? pts)"; Coeffs "Coefficients: (0 to 2^(FFTSize-1)-1)"; StepPeriod "Coefficient Step Period: (2^?)"; coeff_bit_width "Coefficient Bit Width"; input_bit_width "Input Bit Width"; bin_pt_in "Input binary point"; async "asynchronous operation"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; add_latency "Add Latency"; mult_latency "Mult Latency"; bram_latency "BRAM Latency"; conv_latency "Convert latency"; add_pipe_latency "Add Pipeline Latency"; mult_pipe_latency "Mult Pipeline Latency"; quantization "Quantization Behavior"; overflow "Overflow Behavior"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Feedback rotation vector resolution"; max_fanout "Maximum fanout"; use_hdl "Use behavioural HDL for multipliers"; use_embedded "Use embedded multipliers"; bitgrowth "Bit growth instead of shifting"; hardcode_shifts "Hardcode shift schedule"; dsp48_adders "Use DSP48s for adders"
      mask help: FFT internal block.
      mask init:
      | butterfly_direct_init(gcb, ...
      |    'n_inputs', n_inputs, ...
      |    'biplex', biplex, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'StepPeriod', StepPeriod, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'input_bit_width', input_bit_width, ...
      |    'bin_pt_in', bin_pt_in, ...
      |    'hardcode_shifts', hardcode_shifts, ...
      |    'bitgrowth', bitgrowth, ...
      |    'downshift', downshift, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...   
      |    'async', async, ...
      |    'add_latency', add_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'bram_latency', bram_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'add_pipe_latency', add_pipe_latency, ...
      |    'mult_pipe_latency', mult_pipe_latency, ...        
      |    'quantization', quantization, ...
      |    'overflow', overflow, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...    
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'max_fanout', max_fanout, ...
      |    'use_hdl', use_hdl, ...
      |    'use_embedded', use_embedded, ...
      |    'dsp48_adders', dsp48_adders);
  counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=FFTSize-FFTStage+1  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  delay0 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  delay1 : Subsystem  AncestorBlock=casper_library_bus/bus_delay  mask(bus_delay){n_bits=[18 18 18], csp_latency=2^(FFTSize-FFTStage), cmplx=on, enable=off, reg_retiming=on, misc=off}
      mask prompts: n_bits "input bit widths"; csp_latency "latency"; cmplx "complex data"; enable "enable port"; reg_retiming "implement using behavioral HDL"; misc "misc support"
      mask help: Delay components of a bus
      mask init:
      | bus_delay_init(gcb, ...
      |     'enable', enable, ...
      |     'cmplx', cmplx, ...
      |     'n_bits', n_bits, ...
      |     'csp_latency', csp_latency, ...
      |     'reg_retiming', reg_retiming, ...
      |     'misc', misc);
  din0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  din2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dmux1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dsync1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=2  reg_retiming=on  dbl_ovrd=off  block_type=delay
  logical1 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  mux1 : xbsIndex_r4/Mux  inputs=2  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  slice0 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Lower Bit Location + Width  bit1=-(FFTStage - 1)  base1=MSB of Input  bit0=FFTStage - 1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_delay : casper_library_delays/sync_delay  DelayLen=2^(FFTSize - FFTStage)
      link override Constant2: sg_icon_stat=45,26,0,1,white,blue,0,1270bb14,right,,[ ],[ ]  sg_mask_display=fprintf('','COMMENT: begin icon graphics'); patch([0 45 45 0 0 ],[0 0 26 26 0 ],[0.77 0.82 0.91 ]); plot([0 45 45 0 0 ],[0 0 26 26 0 ]); patch([15.325 19.66 22.66 25.66 28.66 22.66 18.325 15.325 ],[16.33 16.33 19.33 16.33 19.33 19.33 19.33 16.33 ],[1 1 1 ]); patch([18.325 22.66 19.66 15.325 18.325 ],[13.33 13.33 16.33 16.33 13.33 ],[0.931 0.946 0.973 ]); patch([15.325 19.66 22.66 18.325 15.325 ],[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
  out1 : Outport
  out2 : Outport  Port=2
  of : Outport  Port=3
  sync_out : Outport  Port=4
  wires:
  in1/1 -> din0/1
  sync/1 -> dsync0/1
  counter/1 -> slice1/1
  slice1/1 -> mux1/1, mux0/1
  mux0/1 -> dmux0/1
  din0/1 -> mux1/2, mux0/3
  dsync0/1 -> dsync1/1, counter/1
  in2/1 -> din2/1
  din2/1 -> delay0/1(din)
  mux1/1 -> dmux1/1
  dmux1/1 -> delay1/1(din)
  delay0/1(dout) -> mux1/3, mux0/2
  dsync1/1 -> sync_delay/1
  shift/1 -> slice0/1
  dmux0/1 -> butterfly_direct/2(b)
  slice0/1 -> butterfly_direct/4(shift)
  delay1/1(dout) -> butterfly_direct/1(a)
  sync_delay/1 -> butterfly_direct/3(sync_in)
  of_in/1 -> logical1/2
  butterfly_direct/3(of) -> logical1/1
  butterfly_direct/1(a+bw) -> out1/1
  butterfly_direct/2(a-bw) -> out2/1
  logical1/1 -> of/1
  butterfly_direct/4(sync_out) -> sync_out/1
