simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 61 of 131)

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_even_real/a_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_even_real/b_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_even_real/op_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_odd_real/a_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_odd_real/b_debus ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> msb_out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/add_odd_real/op_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  concatenate : xbsIndex_r4/Concat  num_inputs=12  dbl_ovrd=off  block_type=concat
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv1 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv10 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv11 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv12 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv2 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv3 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv4 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv5 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv6 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv7 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv8 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/conv9 ==
  note: (ones_bit & 1) -> round-to-even (ones_bit ^ 1) -> round-to-odd (sign_bit & 1)-> round-to-zero (sign_bit ^ 1) -> round-to-inf (X ~| 1) -> round half down (X | 1) -> round half up
  in : Inport
  Concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  Constant : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  adder : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=off  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  almost_half : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=19  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  bit : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=1  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  force1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  force2 : xbsIndex_r4/Reinterpret  force_arith_type=off  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=19  block_type=reinterpret
  tweak_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  tweak_op/1 -> Concat/2
  Constant/1 -> tweak_op/2
  bit/1 -> tweak_op/1
  almost_half/1 -> force2/1
  in/1 -> Reinterpret/1, bit/1
  Concat/1 -> force1/1
  Reinterpret/1 -> Concat/1
  force1/1 -> adder/1
  force2/1 -> adder/2
  adder/1 -> out/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_convert/debus ==
  bus_in : Inport
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=18  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-209  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-38  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-19  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-190  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-171  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-152  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-133  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-114  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-95  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-76  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-57  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out12 : Outport
  out11 : Outport  Port=2
  out10 : Outport  Port=3
  out9 : Outport  Port=4
  out8 : Outport  Port=5
  out7 : Outport  Port=6
  out6 : Outport  Port=7
  out5 : Outport  Port=8
  out4 : Outport  Port=9
  out3 : Outport  Port=10
  out2 : Outport  Port=11
  lsb_out1 : Outport  Port=12
  wires:
  bus_in/1 -> slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> msb_out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_scale/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  concatenate : xbsIndex_r4/Concat  num_inputs=12  dbl_ovrd=off  block_type=concat
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/bus_scale/debus ==
  bus_in : Inport
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-209  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-38  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-19  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-190  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-171  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-152  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-133  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-114  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-95  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-76  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-57  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out12 : Outport
  out11 : Outport  Port=2
  out10 : Outport  Port=3
  out9 : Outport  Port=4
  out8 : Outport  Port=5
  out7 : Outport  Port=6
  out6 : Outport  Port=7
  out5 : Outport  Port=8
  out4 : Outport  Port=9
  out3 : Outport  Port=10
  out2 : Outport  Port=11
  lsb_out1 : Outport  Port=12
  wires:
  bus_in/1 -> slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> msb_out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_a/join ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  concatenate : xbsIndex_r4/Concat  num_inputs=6  dbl_ovrd=off  block_type=concat
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_a/split ==
  bus_in : Inport
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out6 : Outport
  out5 : Outport  Port=2
  out4 : Outport  Port=3
  out3 : Outport  Port=4
  out2 : Outport  Port=5
  lsb_out1 : Outport  Port=6
  wires:
  bus_in/1 -> slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> msb_out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_biplex_real_4x/bi_real_unscr_4x/hilbert0/munge_b/join ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  concatenate : xbsIndex_r4/Concat  num_inputs=6  dbl_ovrd=off  block_type=concat
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
