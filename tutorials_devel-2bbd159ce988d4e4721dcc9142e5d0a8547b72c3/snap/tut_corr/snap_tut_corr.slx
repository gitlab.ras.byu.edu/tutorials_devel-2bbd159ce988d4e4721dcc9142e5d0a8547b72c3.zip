simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 5 of 131)

== system snap_tut_corr/dir_x0/bb ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Gateway Out3/1 -> Scope/4
  Gateway Out2/1 -> Scope/3
  Gateway Out1/1 -> Scope/2
  Gateway Out/1 -> Scope/1
  real/1(data_out) -> Terminator/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  new_acc/1 -> Delay3/1
  vacc_32bit/1(dout) -> Reinterpret/1
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> Gateway Out3/1, vacc_32bit/2(new_acc), Counter/1
  vacc_32bit/2(valid) -> Gateway Out2/1, real/3(we), Counter/2
  Counter/1 -> Gateway Out/1, real/1(addr)
  Reinterpret/1 -> Gateway Out1/1, real/2(data_in)

== system snap_tut_corr/dir_x0/bc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system snap_tut_corr/dir_x0/cc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system snap_tut_corr/dir_x1/aa ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system snap_tut_corr/dir_x1/ab ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system snap_tut_corr/dir_x1/ac ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)

== system snap_tut_corr/dir_x1/bb ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Gateway Out3/1 -> Scope/4
  Gateway Out2/1 -> Scope/3
  Gateway Out1/1 -> Scope/2
  Gateway Out/1 -> Scope/1
  real/1(data_out) -> Terminator/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  new_acc/1 -> Delay3/1
  vacc_32bit/1(dout) -> Reinterpret/1
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> Gateway Out3/1, vacc_32bit/2(new_acc), Counter/1
  vacc_32bit/2(valid) -> Gateway Out2/1, real/3(we), Counter/2
  Counter/1 -> Gateway Out/1, real/1(addr)
  Reinterpret/1 -> Gateway Out1/1, real/2(data_in)

== system snap_tut_corr/dir_x1/bc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system snap_tut_corr/dir_x1/cc ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system snap_tut_corr/fft_wideband_real/del_4x_pol0 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol11 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol3 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol4 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol7 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol8 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_4x_pol9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct1 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct10 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct2 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct5 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct6 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_direct9 ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1

== system snap_tut_corr/fft_wideband_real/del_sync_4x ==
  d : Inport
  q : Outport
  wires:
  d/1 -> q/1
