simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 24 of 131)

== system snap_tut_corr/snapshot_eq/ss/bram ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=64, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=64  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=2, div_size=[32 32], order=[1  0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=2, div_size=[32 32], order=[1  0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=10, data_width=64, data_bin_pt=0, init_vals=[0     1     2     3     4     5     6     7     8     9    10    11    12    13    14    15    16    17    18    19    20    21    22    23    24    25    26    27    28    29    30    31    32    33    34    35    36    37    38    39    40    41    42    43    44    45    46    47    48    49    50    51    52    53    54    55    56    57    58    59    60    61    62    63    64    65    66  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_snapshot_eq_ss_bram_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_snapshot_eq_ss_bram_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_snapshot_eq_ss_bram_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=64  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_snapshot_eq_ss_bram_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_in/1(dout) -> convert_din1/1, sim_mem/2(data)
  we/1 -> convert_we/1, sim_mem/3(we)
  addr/1 -> calc_add/1(in)
  convert_we/1 -> snap_tut_corr_snapshot_eq_ss_bram_we/1
  snap_tut_corr_snapshot_eq_ss_bram_addr/1 -> Terminator/1
  snap_tut_corr_snapshot_eq_ss_bram_data_in/1 -> Terminator1/1
  snap_tut_corr_snapshot_eq_ss_bram_we/1 -> Terminator2/1
  calc_add/1(out) -> convert_addr/1, sim_mem/1(addr)
  data_in/1 -> munge_in/1(din)
  convert_din1/1 -> snap_tut_corr_snapshot_eq_ss_bram_data_in/1
  convert_addr/1 -> snap_tut_corr_snapshot_eq_ss_bram_addr/1
  snap_tut_corr_snapshot_eq_ss_bram_data_out/1 -> munge_out/1(din)
  sim_mem/1(data_out) -> snap_tut_corr_snapshot_eq_ss_bram_data_out/1
  munge_out/1(dout) -> data_out/1

== system snap_tut_corr/snapshot_eq/ss/ctrl ==
  convert1_1 : DataTypeConversion  OutDataTypeStr=fixdt('ufix32_En0')
  convert2_1 : DataTypeConversion  OutDataTypeStr=fixdt('ufix32_En0')  ConvertRealWorld=Stored Integer (SI)
  gain_1 : Gain
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  sim_1 : Constant  Value=0
  slice_reg : xbsIndex_r4/Slice  nbits=32  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  snap_tut_corr_snapshot_eq_ss_ctrl_user_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  in_reg : Outport
  wires:
  snap_tut_corr_snapshot_eq_ss_ctrl_user_data_out/1 -> io_delay/1
  sim_1/1 -> convert1_1/1
  convert1_1/1 -> convert2_1/1
  convert2_1/1 -> gain_1/1
  gain_1/1 -> snap_tut_corr_snapshot_eq_ss_ctrl_user_data_out/1
  io_delay/1 -> slice_reg/1
  slice_reg/1 -> reint1/1
  reint1/1 -> in_reg/1

== system snap_tut_corr/snapshot_eq/ss/ctrl_combine ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  concatenate : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4

== system snap_tut_corr/snapshot_eq/ss/ctrl_split ==
  bus_in : Inport
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret4 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-31  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=2  boolean_output=off  mode=Upper Bit Location + Width  bit1=-29  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-28  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=28  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> lsb_out1/1

== system snap_tut_corr/snapshot_eq/ss/status ==
  out_reg : Inport
  assert_reg : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  cast_gw : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=1  pipeline=off  dbl_ovrd=off  block_type=convert
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  sim_out : Terminator
  snap_tut_corr_snapshot_eq_ss_status_user_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  wires:
  io_delay/1 -> cast_gw/1
  cast_gw/1 -> snap_tut_corr_snapshot_eq_ss_status_user_data_in/1
  snap_tut_corr_snapshot_eq_ss_status_user_data_in/1 -> sim_out/1
  out_reg/1 -> assert_reg/1
  assert_reg/1 -> reint1/1
  reint1/1 -> io_delay/1

== system snap_tut_corr/sync_gen/sync_gen/edge_detect1 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/sync_gen/sync_gen/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/dir_x0/aa/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/aa/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/aa/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/aa/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/aa/vacc_32bit/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x0/aa/vacc_32bit/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x0/ab/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/ab/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ab/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ab/imag/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/ab/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/ab/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ab/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ab/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/ab/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system snap_tut_corr/dir_x0/ab/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system snap_tut_corr/dir_x0/ab/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x0/ab/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x0/ac/imag/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/ac/imag/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ac/imag/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ac/imag/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/ac/real/calc_add ==
  note: Use behavioural HDL so that gets optimised to minimum logic
  note: If reading/writing words smaller than 32 bits, change address so that addressing is big endian instead of little, otherwise pass through
  in : Inport
  add_sub : xbsIndex_r4/AddSub  mode=Subtraction  use_carryin=off  use_carryout=off  en=off  latency=0  precision=User Defined  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  dbl_ovrd=off  block_type=addsub
  concat : xbsIndex_r4/Concat  num_inputs=2  dbl_ovrd=off  block_type=concat
  const : xbsIndex_r4/Constant  const=max(0, 32/data_width-1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=max(1, log2(32/data_width))  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  lsw : xbsIndex_r4/Slice  nbits=max(1, log2(32/data_width))  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  manipulate : xbsIndex_r4/Constant  const=min(1, floor(32/data_width) - 1)  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=sample_rate  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  msw : xbsIndex_r4/Slice  nbits=addr_width - max(1, log2(32/data_width))  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  mux : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  out : Outport
  wires:
  convert_addr/1 -> mux/2, msw/1, lsw/1
  const/1 -> add_sub/1
  lsw/1 -> add_sub/2
  mux/1 -> out/1
  manipulate/1 -> mux/1
  concat/1 -> mux/3
  msw/1 -> concat/1
  add_sub/1 -> concat/2
  in/1 -> convert_addr/1

== system snap_tut_corr/dir_x0/ac/real/munge_in ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ac/real/munge_out ==
  din : Inport
  reinterpret_out : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  dout : Outport
  wires:
  din/1 -> reinterpret_out/1
  reinterpret_out/1 -> dout/1

== system snap_tut_corr/dir_x0/ac/real/sim_mem ==
  addr : Inport
  data : Inport  Port=2
  we : Inport  Port=3
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=single
  Data Type Conversion1 : DataTypeConversion  OutDataTypeStr=double
  Data Type Conversion2 : DataTypeConversion  OutDataTypeStr=boolean
  sfunc : M-S-Function  FunctionName=shared_bram_sim_sfunc  Parameters=depth_bits, latency, init_vals  mask{depth_bits=addr_width, latency=csp_latency, init_vals=init_vals}
      mask prompts: depth_bits "Depth (2^?):"; latency "Latency (>=1):"; init_vals "Initial values:"
  sim_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_data : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=off  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  sfunc/1 -> data_out/1  "output"
  Data Type Conversion2/1 -> sfunc/3  "we"
  Data Type Conversion1/1 -> sfunc/2  "data_in"
  Data Type Conversion/1 -> sfunc/1  "addr"
  sim_we/1 -> Data Type Conversion2/1
  sim_data/1 -> Data Type Conversion1/1
  sim_addr/1 -> Data Type Conversion/1
  we/1 -> sim_we/1
  data/1 -> sim_data/1
  addr/1 -> sim_addr/1

== system snap_tut_corr/dir_x0/ac/vacc_0/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Constant2/1 -> Single Port RAM/3
  In1/1 -> Single Port RAM/2
  Counter/1 -> Single Port RAM/1
  Single Port RAM/1 -> Out1/1

== system snap_tut_corr/dir_x0/ac/vacc_0/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  Counter3/1 -> Relational5/1
  Constant5/1 -> Relational5/2
  Relational5/1 -> Counter3/2, out/1
  in/1 -> posedge/1(In)
  posedge/1(Out) -> Counter3/1

== system snap_tut_corr/dir_x0/ac/vacc_1/delay_bram ==
  In1 : Inport
  Constant2 : xbsIndex_r4/Constant  const=1  gui_display_data_type=Fixed-point  arith_type=Boolean  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Count Limited  cnt_to=DelayLen - bram_latency - 1  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=BitWidth  bin_pt=0  load_pin=off  rst=off  en=off  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=off  dbl_ovrd=off  block_type=counter
  Single Port RAM : xbsIndex_r4/Single Port RAM  depth=2^BitWidth  initVector=0  distributed_mem=Block RAM  write_mode=Read Before Write  rst=off  init_reg=0  en=off  latency=bram_latency  optimize=Area  dbl_ovrd=off  block_type=spram
  Out1 : Outport
  wires:
  Single Port RAM/1 -> Out1/1
  Counter/1 -> Single Port RAM/1
  In1/1 -> Single Port RAM/2
  Constant2/1 -> Single Port RAM/3

== system snap_tut_corr/dir_x0/ac/vacc_1/pulse_ext ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  posedge : Subsystem  Tag=Rising Edge Detector
  out : Outport
  wires:
  posedge/1(Out) -> Counter3/1
  in/1 -> posedge/1(In)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1
