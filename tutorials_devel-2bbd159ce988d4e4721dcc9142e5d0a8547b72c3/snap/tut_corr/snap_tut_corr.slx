simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 38 of 131)

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/reorder/we_expand ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> msb_out2/1
  slice1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/reorder/we_replicate ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=2}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_0 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  din0_1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/barrel_switcher ==
  sel : Inport
  sync_in : Inport  Port=2
  In1 : Inport  Port=3
  In2 : Inport  Port=4
  Delay_sync : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Mux11 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Mux21 : xbsIndex_r4/Mux  inputs=2  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  Slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=off  mode=Upper Bit Location + Width  bit1=-0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  sync_out : Outport
  Out1 : Outport  Port=2
  Out2 : Outport  Port=3
  wires:
  sync_in/1 -> Delay_sync/1
  Delay_sync/1 -> sync_out/1
  sel/1 -> Slice1/1
  Slice1/1 -> Mux11/1, Mux21/1
  In1/1 -> Mux11/2, Mux21/3
  Mux11/1 -> Out1/1
  In2/1 -> Mux21/2, Mux11/3
  Mux21/1 -> Out2/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/db0 ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/df1 ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_unscrambler/square_transposer/dsync ==
  din : Inport
  dly : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=DelayLen  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dout : Outport
  wires:
  din/1 -> dly/1
  dly/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/munge/join ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  concatenate : xbsIndex_r4/Concat  num_inputs=8  dbl_ovrd=off  block_type=concat
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/munge/split ==
  bus_in : Inport
  reinterpret{1..8} (8 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-126  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out8 : Outport
  out7 : Outport  Port=2
  out6 : Outport  Port=3
  out5 : Outport  Port=4
  out4 : Outport  Port=5
  out3 : Outport  Port=6
  out2 : Outport  Port=7
  lsb_out1 : Outport  Port=8
  wires:
  bus_in/1 -> slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> msb_out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/A_bussify0 ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  concatenate : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/B_bussify0 ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  concatenate : xbsIndex_r4/Concat  num_inputs=4  dbl_ovrd=off  block_type=concat
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_addra0 ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-27  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-9  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_addrb0 ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-27  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=-9  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_dina0 ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_dinb0 ==
  bus_in : Inport
  reinterpret{1..4} (4 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=36  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> msb_out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_wea0 ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-3  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> msb_out4/1
  slice3/1 -> out3/1
  slice2/1 -> out2/1
  slice1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/debus_web0 ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-3  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out4 : Outport
  out3 : Outport  Port=2
  out2 : Outport  Port=3
  lsb_out1 : Outport  Port=4
  wires:
  bus_in/1 -> slice4/1, slice3/1, slice2/1, slice1/1
  slice4/1 -> msb_out4/1
  slice3/1 -> out3/1
  slice2/1 -> out2/1
  slice1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/rep_addra0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=4}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  din0_2/1 -> bussify/3(in3)
  din0_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/rep_addrb0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=4}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  din0_{0..3} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  out : Outport
  wires:
  in/1 -> din0_0/1, din0_1/1, din0_2/1, din0_3/1
  din0_0/1 -> bussify/1(in1)
  din0_1/1 -> bussify/2(in2)
  din0_2/1 -> bussify/3(in3)
  din0_3/1 -> bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/rep_wea0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=4}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  out : Outport
  wires:
  in/1 -> bussify/1(in1), bussify/2(in2), bussify/3(in3), bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_coeff_gen/rom/rep_web0 ==
  in : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=4}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  out : Outport
  wires:
  in/1 -> bussify/1(in1), bussify/2(in2), bussify/3(in3), bussify/4(in4)
  bussify/1(bus_out) -> out/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree0 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree1 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree10 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree11 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree2 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree3 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree4 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree5 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree6 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree7 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree8 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/add_tree9 ==
  sync : Inport
  din1 : Inport  Port=2
  din2 : Inport  Port=3
  din3 : Inport  Port=4
  din4 : Inport  Port=5
  addr1 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr2 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  addr3 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=14  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  use_rpm=on  dbl_ovrd=off  block_type=addsub
  sync_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=on  dbl_ovrd=off  block_type=delay
  sync_out : Outport
  dout : Outport  Port=2
  wires:
  sync/1 -> sync_delay/1
  sync_delay/1 -> sync_out/1
  din1/1 -> addr1/1
  din2/1 -> addr1/2
  din3/1 -> addr2/1
  din4/1 -> addr2/2
  addr1/1 -> addr3/1
  addr2/1 -> addr3/2
  addr3/1 -> dout/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/d_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  concatenate : xbsIndex_r4/Concat  num_inputs=12  dbl_ovrd=off  block_type=concat
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/expand0 ==
  bus_in : Inport
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=24  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-286  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-52  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-26  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-260  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-234  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-208  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-182  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-156  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-130  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-104  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-78  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out12 : Outport
  out11 : Outport  Port=2
  out10 : Outport  Port=3
  out9 : Outport  Port=4
  out8 : Outport  Port=5
  out7 : Outport  Port=6
  out6 : Outport  Port=7
  out5 : Outport  Port=8
  out4 : Outport  Port=9
  out3 : Outport  Port=10
  out2 : Outport  Port=11
  lsb_out1 : Outport  Port=12
  wires:
  bus_in/1 -> slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> msb_out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/pfb_fir_generic/pfb_fir_taps/bus_adder_tree/expand1 ==
  bus_in : Inport
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=24  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-286  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice10 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-52  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice11 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-26  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice12 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-260  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-234  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-208  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-182  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-156  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice7 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-130  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice8 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-104  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice9 : xbsIndex_r4/Slice  nbits=26  boolean_output=off  mode=Upper Bit Location + Width  bit1=-78  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out12 : Outport
  out11 : Outport  Port=2
  out10 : Outport  Port=3
  out9 : Outport  Port=4
  out8 : Outport  Port=5
  out7 : Outport  Port=6
  out6 : Outport  Port=7
  out5 : Outport  Port=8
  out4 : Outport  Port=9
  out3 : Outport  Port=10
  out2 : Outport  Port=11
  lsb_out1 : Outport  Port=12
  wires:
  bus_in/1 -> slice12/1, slice11/1, slice10/1, slice9/1, slice8/1, slice7/1, slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice12/1 -> reinterpret12/1
  reinterpret12/1 -> msb_out12/1
  slice11/1 -> reinterpret11/1
  reinterpret11/1 -> out11/1
  slice10/1 -> reinterpret10/1
  reinterpret10/1 -> out10/1
  slice9/1 -> reinterpret9/1
  reinterpret9/1 -> out9/1
  slice8/1 -> reinterpret8/1
  reinterpret8/1 -> out8/1
  slice7/1 -> reinterpret7/1
  reinterpret7/1 -> out7/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1
