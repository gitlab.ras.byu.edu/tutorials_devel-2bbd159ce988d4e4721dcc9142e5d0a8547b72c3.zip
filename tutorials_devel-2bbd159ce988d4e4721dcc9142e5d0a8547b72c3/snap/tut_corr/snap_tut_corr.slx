simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 34 of 131)

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle ==
  ai : Inport
  bi : Inport  Port=2
  sync_in : Inport  Port=3
  bus_convert : Subsystem  AncestorBlock=casper_library_bus/bus_convert  mask(bus_convert){n_bits_in=repmat(input_bit_width+coeff_bit_width+1, 1, n_inputs), bin_pt_in=(bin_pt_in+coeff_bit_width-1), cmplx=on, n_bits_out=input_bit_width+1, bin_pt_out=bin_pt_in, quantization=2, overflow=0, csp_latency=conv_latency, of=off, misc=on}
      mask prompts: n_bits_in "input bit widths"; bin_pt_in "input binary points"; cmplx "input complex"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1, Round (unbiased: Even Values)=2)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; csp_latency "latency"; of "overflow indication"; misc "misc support"
      mask help: Convert components of busses
      mask init:
      | bus_convert_init(gcb, ...
      |     'n_bits_in', n_bits_in, ...
      |     'bin_pt_in', bin_pt_in, ...
      |     'cmplx', cmplx, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'csp_latency', csp_latency, ...
      |     'misc', misc, ...
      |     'of', of);
  bus_create : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[n_inputs*input_bit_width*2, 1+(n_inputs*input_bit_width*2)], outputBinaryPt=[0 0], outputArithmeticType=[0 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_expand1 : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[1 216], outputBinaryPt=[0 0], outputArithmeticType=[2 0], show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  bus_mult : Subsystem  AncestorBlock=casper_library_bus/bus_mult  mask(bus_mult){n_bits_a=coeff_bit_width, bin_pt_a=coeff_bit_width-1, type_a=1, cmplx_a=on, n_bits_b=[18 18 18 18 18 18], bin_pt_b=bin_pt_in, type_b=1, cmplx_b=on, misc=on, floating_point=off, float_type=single, input_vec_a=1, input_vec_b=1, frac_width=24, exp_width=8, n_bits_out=input_bit_width+coeff_bit_width+1, bin_pt_out=(bin_pt_in+coeff_bit_width-1), type_out=1, quantization=0, overflow=0, mult_latency=mult_latency, add_latency=add_latency, conv_latency=0, max_fanout=max_fanout, fan_latency=4, multiplier_implementation=behavioral HDL, pipeline_cmult_en=off, pipeline_latency=0}
      mask prompts: n_bits_a "a input bit widths"; bin_pt_a "a input binary points"; type_a "a input type (Unsigned=0, Signed=1)"; cmplx_a "a input complex"; n_bits_b "b input bit widths"; bin_pt_b "b input binary points"; type_b "b input type (Unsigned=0, Signed=1)"; cmplx_b "b input complex"; misc "misc support"; floating_point "floating point"; float_type "float type"; input_vec_a "a input vector in bus"; input_vec_b "b input vector in bus"; frac_width "fraction width"; exp_width "exponent width"; n_bits_out "output bit widths"; bin_pt_out "output binary points"; type_out "output type (Unsigned=0, Signed=1)"; quantization "quantization strategy (Truncate=0, Round  (unbiased: +/- Inf)=1)"; overflow "overflow strategy (Wrap=0, Saturate=1, Flag as error=2)"; mult_latency "multiplier latency"; add_latency "adder latency"; conv_latency "convert latency"; max_fanout "limit fanout to ?"; fan_latency "fanout register latency"; multiplier_implementation "multiplier implementation"; pipeline_cmult_en "pipeline complex mult"; pipeline_latency "pipeline latency"
      mask help: Multiply components of two busses
      mask init:
      | bus_mult_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'type_a', type_a, ...
      |     'cmplx_a', cmplx_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'type_b', type_b, ...
      |     'cmplx_b', cmplx_b, ...
      |     'n_bits_out', n_bits_out, ...
      |     'bin_pt_out', bin_pt_out, ...
      |     'type_out', type_out, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'input_vec_a', input_vec_a, ...
      |     'input_vec_b', input_vec_b, ...
      |     'frac_width', frac_width, ...         
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'max_fanout', max_fanout, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'fan_latency', fan_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'misc', misc);
  coeff_gen : Subsystem  AncestorBlock=casper_library_ffts_twiddle_coeff_gen/coeff_gen  mask(coeff_gen){FFTSize=FFTSize, Coeffs=[0 256 128 384 64 320 192 448 32 288 160 416 96 352 224 480 16 272 144 400 80 336 208 464 48 304 176 432 112 368 240 496 8 264 136 392 72 328 200 456 40 296 168 424 104 360 232 488 24 280 152 408 88 344 216 472 56 312 184 440 120 376 248 504 4 260 132 388 68 324 196 452 36 292 164 420 100 356 228 484 20 276 148 404 84 340 212 468 52 308 180 436 116 372 244 500 12 268 140 396 76 332 204 460 44 300 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, coeff_bit_width=coeff_bit_width, StepPeriod=StepPeriod, async=off, misc=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, bram_latency=bram_latency, mult_latency=mult_latency, add_latency=add_latency, conv_latency=conv_latency, coeffs_bit_limit=coeffs_bit_limit, coeff_sharing=off, coeff_decimation=off, coeff_generation=off, cal_bits=cal_bits, n_bits_rotation=n_bits_rotation, quantization=Round  (unbiased: Even Values)}
      mask prompts: FFTSize "fft size (2^?)"; Coeffs "Coefficients"; coeff_bit_width "Coefficient Bit Width:"; StepPeriod "Step Period: (2^?)"; async "asynchronous operation"; misc "misc port"; floating_point "floating point"; exp_width "exponential width"; frac_width "fractional width"; bram_latency "BRAM latency"; mult_latency "Multiplier latency"; add_latency "Adder latency"; conv_latency "Convert latency"; coeffs_bit_limit "Number bits above which to store stage's coefficients in BRAM (2^? bits)"; coeff_sharing "BRAM sharing in coeff storage"; coeff_decimation "Store a fraction of coeff factors where useful"; coeff_generation "Generate coeffs with multipliers where useful"; cal_bits "Number calibration locations when generating coeffs (2^?)"; n_bits_rotation "Rotation vector resolution"; quantization "Quantization strategy"
      mask help: Generates a sequence of complex coefficients for use in generating twiddle factors for FFTs.
      mask init:
      | coeff_gen_init(gcb, ...
      |    'FFTSize', FFTSize, ...
      |    'Coeffs', Coeffs, ...
      |    'coeff_bit_width', coeff_bit_width, ...
      |    'floating_point', floating_point, ...
      |    'float_type', float_type, ...
      |    'exp_width', exp_width, ...
      |    'frac_width', frac_width, ...       
      |    'StepPeriod', StepPeriod, ...
      |    'async', async, ...
      |    'misc', misc, ...
      |    'bram_latency', bram_latency, ...
      |    'mult_latency', mult_latency, ...
      |    'add_latency', add_latency, ...
      |    'conv_latency', conv_latency, ...
      |    'coeffs_bit_limit', coeffs_bit_limit, ...
      |    'coeff_sharing', coeff_sharing, ...
      |    'coeff_decimation', coeff_decimation, ...
      |    'coeff_generation', coeff_generation, ...
      |    'cal_bits', cal_bits, ...
      |    'n_bits_rotation', n_bits_rotation, ...
      |    'quantization', quantization);
  ao : Outport
  bwo : Outport  Port=2
  sync_out : Outport  Port=3
  wires:
  bi/1 -> bus_create/1(in1)
  sync_in/1 -> bus_create/2(in2), coeff_gen/1(rst)
  ai/1 -> bus_create/3(in3)
  bus_create/1(bus_out) -> coeff_gen/2(misci)
  coeff_gen/2(misco) -> bus_expand/1(bus_in)
  coeff_gen/1(w) -> bus_mult/1(a)
  bus_expand/2(lsb_out1) -> bus_mult/3(misci)
  bus_expand/1(msb_out2) -> bus_mult/2(b)
  bus_mult/1(a*b) -> bus_convert/1(din)
  bus_mult/2(misco) -> bus_convert/2(misci)
  bus_convert/1(dout) -> bwo/1
  bus_convert/2(misco) -> bus_expand1/1(bus_in)
  bus_expand1/1(msb_out2) -> sync_out/1
  bus_expand1/2(lsb_out1) -> ao/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_add ==
  a : Inport
  b : Inport  Port=2
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[18  18  18  18  18  18], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  addsub{1..6} (6 alike) : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=1  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=20  bin_pt=17  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=on  dbl_ovrd=off  block_type=addsub
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[19  19  19  19  19  19], outputBinaryPt=[17  17  17  17  17  17], outputArithmeticType=[1  1  1  1  1  1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  op_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  wires:
  a/1 -> a_debus/1(bus_in)
  b/1 -> b_debus/1(bus_in)
  a_debus/1(msb_out6) -> addsub1/1
  b_debus/1(msb_out6) -> addsub1/2
  a_debus/2(out5) -> addsub2/1
  b_debus/2(out5) -> addsub2/2
  a_debus/3(out4) -> addsub3/1
  b_debus/3(out4) -> addsub3/2
  a_debus/4(out3) -> addsub4/1
  b_debus/4(out3) -> addsub4/2
  a_debus/5(out2) -> addsub5/1
  b_debus/5(out2) -> addsub5/2
  a_debus/6(lsb_out1) -> addsub6/1
  b_debus/6(lsb_out1) -> addsub6/2
  addsub1/1 -> op_bussify/1(in1)
  addsub2/1 -> op_bussify/2(in2)
  addsub3/1 -> op_bussify/3(in3)
  addsub4/1 -> op_bussify/4(in4)
  addsub5/1 -> op_bussify/5(in5)
  addsub6/1 -> op_bussify/6(in6)
  op_bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_convert ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert_of  mask(convert_of){bit_width_i=21, binary_point_i=18, bit_width_o=18, binary_point_o=17, csp_latency=1, overflow=Wrap, quantization=Round  (unbiased: even values)}
      mask prompts: bit_width_i "Bit Width In"; binary_point_i "Binary Point In"; bit_width_o "Bit Width Out"; binary_point_o "Binary Point Out"; csp_latency "Latency"; overflow "Overflow Behaviour"; quantization "Quantization Behaviour"
      mask help: Converts from one 2's complement bit-width and/or binary point position to another. Includes underflow/overflow indicator.
      mask init:
      | convert_of_init(gcb, ...
      |     'bit_width_i', bit_width_i, ...
      |     'binary_point_i', binary_point_i, ...
      |     'bit_width_o', bit_width_o, ...
      |     'binary_point_o', binary_point_o, ...
      |     'latency',csp_latency, ...
      |     'overflow', overflow, ...
      |     'quantization', quantization);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[21 21 21 21 21 21 21 21 21 21 21 21], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  of_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  dout : Outport
  overflow : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(din)
  debus/2(out11) -> conv2/1(din)
  debus/3(out10) -> conv3/1(din)
  debus/4(out9) -> conv4/1(din)
  debus/5(out8) -> conv5/1(din)
  debus/6(out7) -> conv6/1(din)
  debus/7(out6) -> conv7/1(din)
  debus/8(out5) -> conv8/1(din)
  debus/9(out4) -> conv9/1(din)
  debus/10(out3) -> conv10/1(din)
  debus/11(out2) -> conv11/1(din)
  debus/12(lsb_out1) -> conv12/1(din)
  conv1/1(dout) -> bussify/1(in1)
  conv2/1(dout) -> bussify/2(in2)
  conv3/1(dout) -> bussify/3(in3)
  conv4/1(dout) -> bussify/4(in4)
  conv5/1(dout) -> bussify/5(in5)
  conv6/1(dout) -> bussify/6(in6)
  conv7/1(dout) -> bussify/7(in7)
  conv8/1(dout) -> bussify/8(in8)
  conv9/1(dout) -> bussify/9(in9)
  conv10/1(dout) -> bussify/10(in10)
  conv11/1(dout) -> bussify/11(in11)
  conv12/1(dout) -> bussify/12(in12)
  conv1/2(of) -> of_bussify/1(in1)
  conv2/2(of) -> of_bussify/2(in2)
  conv3/2(of) -> of_bussify/3(in3)
  conv4/2(of) -> of_bussify/4(in4)
  conv5/2(of) -> of_bussify/5(in5)
  conv6/2(of) -> of_bussify/6(in6)
  conv7/2(of) -> of_bussify/7(in7)
  conv8/2(of) -> of_bussify/8(in8)
  conv9/2(of) -> of_bussify/9(in9)
  conv10/2(of) -> of_bussify/10(in10)
  conv11/2(of) -> of_bussify/11(in11)
  conv12/2(of) -> of_bussify/12(in12)
  bussify/1(bus_out) -> dout/1
  of_bussify/1(bus_out) -> overflow/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=-108  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=108  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_norm0 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv{1..12} (12 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=21  bin_pt=18  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[17 17 17 17 17 17 17 17 17 17 17 17], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1
  debus/2(out11) -> conv2/1
  debus/3(out10) -> conv3/1
  debus/4(out9) -> conv4/1
  debus/5(out8) -> conv5/1
  debus/6(out7) -> conv6/1
  debus/7(out6) -> conv7/1
  debus/8(out5) -> conv8/1
  debus/9(out4) -> conv9/1
  debus/10(out3) -> conv10/1
  debus/11(out2) -> conv11/1
  debus/12(lsb_out1) -> conv12/1
  conv1/1 -> bussify/1(in1)
  conv2/1 -> bussify/2(in2)
  conv3/1 -> bussify/3(in3)
  conv4/1 -> bussify/4(in4)
  conv5/1 -> bussify/5(in5)
  conv6/1 -> bussify/6(in6)
  conv7/1 -> bussify/7(in7)
  conv8/1 -> bussify/8(in8)
  conv9/1 -> bussify/9(in9)
  conv10/1 -> bussify/10(in10)
  conv11/1 -> bussify/11(in11)
  conv12/1 -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_norm1 ==
  din : Inport
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=18, n_bits_out=21, bin_pt_out=18, quantization=Truncate, overflow=Wrap, csp_latency=0}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[20 20 20 20 20 20 20 20 20 20 20 20], outputBinaryPt=[18 18 18 18 18 18 18 18 18 18 18 18], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dout : Outport
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(in)
  debus/2(out11) -> conv2/1(in)
  debus/3(out10) -> conv3/1(in)
  debus/4(out9) -> conv4/1(in)
  debus/5(out8) -> conv5/1(in)
  debus/6(out7) -> conv6/1(in)
  debus/7(out6) -> conv7/1(in)
  debus/8(out5) -> conv8/1(in)
  debus/9(out4) -> conv9/1(in)
  debus/10(out3) -> conv10/1(in)
  debus/11(out2) -> conv11/1(in)
  debus/12(lsb_out1) -> conv12/1(in)
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1
