simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 54 of 131)

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_convert ==
  din : Inport
  misci : Inport  Port=2
  bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=12}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  conv1 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv10 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv11 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv12 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv2 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv3 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv4 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv5 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv6 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv7 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv8 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  conv9 : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=34, n_bits_out=19, bin_pt_out=17, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=1}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[37 37 37 37 37 37 37 37 37 37 37 37], outputBinaryPt=[34 34 34 34 34 34 34 34 34 34 34 34], outputArithmeticType=[1 1 1 1 1 1 1 1 1 1 1 1], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dmisc : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=csp_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  dout : Outport
  misco : Outport  Port=2
  wires:
  din/1 -> debus/1(bus_in)
  debus/1(msb_out12) -> conv1/1(in)
  debus/2(out11) -> conv2/1(in)
  debus/3(out10) -> conv3/1(in)
  debus/4(out9) -> conv4/1(in)
  debus/5(out8) -> conv5/1(in)
  debus/6(out7) -> conv6/1(in)
  debus/7(out6) -> conv7/1(in)
  debus/8(out5) -> conv8/1(in)
  debus/9(out4) -> conv9/1(in)
  debus/10(out3) -> conv10/1(in)
  debus/11(out2) -> conv11/1(in)
  debus/12(lsb_out1) -> conv12/1(in)
  misci/1 -> dmisc/1
  conv1/1(out) -> bussify/1(in1)
  conv2/1(out) -> bussify/2(in2)
  conv3/1(out) -> bussify/3(in3)
  conv4/1(out) -> bussify/4(in4)
  conv5/1(out) -> bussify/5(in5)
  conv6/1(out) -> bussify/6(in6)
  conv7/1(out) -> bussify/7(in7)
  conv8/1(out) -> bussify/8(in8)
  conv9/1(out) -> bussify/9(in9)
  conv10/1(out) -> bussify/10(in10)
  conv11/1(out) -> bussify/11(in11)
  conv12/1(out) -> bussify/12(in12)
  bussify/1(bus_out) -> dout/1
  dmisc/1 -> misco/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_create ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  concatenate : xbsIndex_r4/Concat  num_inputs=3  dbl_ovrd=off  block_type=concat
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret3 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_expand ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterpret2 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=217  boolean_output=off  mode=Upper Bit Location + Width  bit1=-216  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=216  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_expand1 ==
  bus_in : Inport
  reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=216  boolean_output=off  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out2 : Outport
  lsb_out1 : Outport  Port=2
  wires:
  bus_in/1 -> slice2/1, slice1/1
  slice2/1 -> msb_out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/bus_mult ==
  a : Inport
  b : Inport  Port=2
  misci : Inport  Port=3
  a*b_bussify : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=6}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  a_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  b_debus : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of arbitrary size, outputNum=1, outputWidth=[36 36 36 36 36 36], outputBinaryPt=[0 0 0 0 0 0], outputArithmeticType=[0 0 0 0 0 0], show_format=on, outputToWorkspace=off, variablePrefix=, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width [msb ... lsb]:"; outputBinaryPt "Output binary point position [msb ... lsb]:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2) [msb ... lsb]:"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  dmisc : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=mult_latency+add_latency+conv_latency+fan_latency  reg_retiming=on  dbl_ovrd=off  block_type=delay
  mult1 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult2 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult3 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult4 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult5 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  mult6 : Subsystem  AncestorBlock=casper_library_multipliers/cmult  mask(cmult){n_bits_a=18, bin_pt_a=17, n_bits_b=18, bin_pt_b=17, n_bits_ab=37, bin_pt_ab=34, quantization=Truncate, overflow=Wrap, conjugated=off, async=off, pipelined_enable=on, floating_point=off, float_type=single, exp_width=8, frac_width=24, in_latency=1, mult_latency=3, add_latency=1, conv_latency=0, pipeline_cmult_en=off, pipeline_latency=0, multiplier_implementation=behavioral HDL}
      mask prompts: n_bits_a "Number of Bits 'a'"; bin_pt_a "Binary Point 'a'"; n_bits_b "Number of Bits 'b'"; bin_pt_b "Binary Point 'b'"; n_bits_ab "Number of Bits 'ab'"; bin_pt_ab "Binary Point 'ab'"; conjugated "Conjugate"; async "asynchronous operation"; pipelined_enable "enable pipeline"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; in_latency "Input latency"; mult_latency "Multiplier Latency"; add_latency "Adder Latency"; conv_latency "Convert latency"; pipeline_cmult_en "Pipeline cmult enable"; pipeline_latency "Pipeline latency"; multiplier_implementation "Multiplier implementation"
      mask help: Multiplies two complex numbers using 4 multipliers and 2 adders. Conjugation is optional.
      mask init:
      | cmult_init(gcb, ...
      |     'n_bits_a',n_bits_a, ...
      |     'bin_pt_a',bin_pt_a, ...
      |     'n_bits_b',n_bits_b, ...
      |     'bin_pt_b',bin_pt_b, ...
      |     'n_bits_ab',n_bits_ab, ...
      |     'bin_pt_ab',bin_pt_ab, ...
      |     'quantization',quantization, ...
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...    
      |     'overflow', overflow, ...
      |     'in_latency', in_latency, ...
      |     'mult_latency', mult_latency, ...
      |     'add_latency', add_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'conjugated', conjugated, ...
      |     'pipeline_cmult_en', pipeline_cmult_en, ...
      |     'pipeline_latency', pipeline_latency, ...
      |     'multiplier_implementation', multiplier_implementation, ...
      |     'async', async, ...
      |     'pipelined_enable', pipelined_enable);
  repa : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=3, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  repb : Subsystem  AncestorBlock=casper_library_bus/bus_replicate  mask(bus_replicate){replication=1, csp_latency=3, misc=off, implementation=core}
      mask prompts: replication "replication factor"; csp_latency "latency"; misc "misc support"; implementation "delay implementation"
      mask help: Output bus formed by replicating input bus a number of times
      mask init:
      | bus_replicate_init(gcb, ...
      |     'replication', replication, ...
      |     'csp_latency', csp_latency, ...
      |     'implementation', implementation, ...
      |     'misc', misc);
  a*b : Outport
  misco : Outport  Port=2
  wires:
  a/1 -> repa/1(in)
  b/1 -> repb/1(in)
  repa/1(out) -> a_debus/1(bus_in)
  repb/1(out) -> b_debus/1(bus_in)
  a_debus/1(msb_lsb_out1) -> mult1/1(a), mult2/1(a), mult3/1(a), mult4/1(a), mult5/1(a), mult6/1(a)
  b_debus/1(msb_out6) -> mult1/2(b)
  b_debus/2(out5) -> mult2/2(b)
  b_debus/3(out4) -> mult3/2(b)
  b_debus/4(out3) -> mult4/2(b)
  b_debus/5(out2) -> mult5/2(b)
  b_debus/6(lsb_out1) -> mult6/2(b)
  misci/1 -> dmisc/1
  mult1/1(ab) -> a*b_bussify/1(in1)
  mult2/1(ab) -> a*b_bussify/2(in2)
  mult3/1(ab) -> a*b_bussify/3(in3)
  mult4/1(ab) -> a*b_bussify/4(in4)
  mult5/1(ab) -> a*b_bussify/5(in5)
  mult6/1(ab) -> a*b_bussify/6(in6)
  a*b_bussify/1(bus_out) -> a*b/1
  dmisc/1 -> misco/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly0_0/twiddle/coeff_gen ==
  rst : Inport
  misci : Inport  Port=2
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=9  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=on  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Slice : xbsIndex_r4/Slice  nbits=9  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  cosin : Subsystem  Tag=casper:cosin  AncestorBlock=casper_library_downconverter/cosin  mask(cosin){output0=cos, output1=-sin, indep_theta=off, phase=0, fraction=1, table_bits=9, n_bits=18, bin_pt=17, floating_point=off, float_type=single, exp_width=8, frac_width=24, store=1, pack=on, bram=BRAM, misc=on, bram_latency=3, add_latency=1, mux_latency=2, neg_latency=2, conv_latency=1}
      mask prompts: output0 "first output function"; output1 "second output function"; indep_theta "Independent theta values"; phase "initial phase offset (?*(2*pi))"; fraction "fraction of cycle period to output (1/2^?)"; table_bits "samples in cycle period fraction to output (2^?)"; n_bits "bit width"; bin_pt "binary point"; floating_point "floating point"; float_type "float type"; exp_width "exponent width"; frac_width "fraction width"; store "fraction of cycle period to store (1/2^?)"; pack "pack lookup values in same output word"; bram "BRAM implementation"; misc "Miscellaneous port"; bram_latency "bram latency"; add_latency "large adder latency"; mux_latency "mux latency"; neg_latency "negate latency"; conv_latency "convert latency"
      mask init:
      | cosin_init(gcb, ...
      |     'output0', output0, ...    
      |     'output1', output1, ...
      |     'indep_theta', indep_theta, ...
      |     'phase', phase, ...
      |     'fraction', fraction, ...
      |     'table_bits', table_bits, ...  
      |     'n_bits', n_bits, ...      
      |     'bin_pt', bin_pt, ...    
      |     'floating_point', floating_point, ...
      |     'float_type', float_type, ...
      |     'exp_width', exp_width, ...
      |     'frac_width', frac_width, ...         
      |     'bram_latency', bram_latency, ...
      |     'add_latency', add_latency, ...
      |     'mux_latency', mux_latency, ...
      |     'neg_latency', neg_latency, ...
      |     'conv_latency', conv_latency, ...
      |     'store', store, ...
      |     'pack', pack, ...
      |     'bram', bram, ...
      |     'misc', misc);
  ri_to_c : casper_library_misc/ri_to_c
  w : Outport
  misco : Outport  Port=2
  wires:
  ri_to_c/1 -> w/1
  rst/1 -> Counter/1
  Counter/1 -> Slice/1
  Slice/1 -> cosin/1(theta)
  cosin/1(cos) -> ri_to_c/1
  cosin/2(-sin) -> ri_to_c/2
  misci/1 -> cosin/2(misci)
  cosin/3(misco) -> misco/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_add/a_debus ==
  bus_in : Inport
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-90  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-72  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-54  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-36  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=-18  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=18  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out6 : Outport
  out5 : Outport  Port=2
  out4 : Outport  Port=3
  out3 : Outport  Port=4
  out2 : Outport  Port=5
  lsb_out1 : Outport  Port=6
  wires:
  bus_in/1 -> slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> msb_out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_add/b_debus ==
  bus_in : Inport
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=17  block_type=reinterpret
  slice1 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-95  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-76  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-57  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice4 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-38  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice5 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=-19  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice6 : xbsIndex_r4/Slice  nbits=19  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out6 : Outport
  out5 : Outport  Port=2
  out4 : Outport  Port=3
  out3 : Outport  Port=4
  out2 : Outport  Port=5
  lsb_out1 : Outport  Port=6
  wires:
  bus_in/1 -> slice6/1, slice5/1, slice4/1, slice3/1, slice2/1, slice1/1
  slice6/1 -> reinterpret6/1
  reinterpret6/1 -> msb_out6/1
  slice5/1 -> reinterpret5/1
  reinterpret5/1 -> out5/1
  slice4/1 -> reinterpret4/1
  reinterpret4/1 -> out4/1
  slice3/1 -> reinterpret3/1
  reinterpret3/1 -> out3/1
  slice2/1 -> reinterpret2/1
  reinterpret2/1 -> out2/1
  slice1/1 -> reinterpret1/1
  reinterpret1/1 -> lsb_out1/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_add/op_bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  concatenate : xbsIndex_r4/Concat  num_inputs=6  dbl_ovrd=off  block_type=concat
  reinterpret{1..6} (6 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_convert/bussify ==
  in1 : Inport
  in2 : Inport  Port=2
  in3 : Inport  Port=3
  in4 : Inport  Port=4
  in5 : Inport  Port=5
  in6 : Inport  Port=6
  in7 : Inport  Port=7
  in8 : Inport  Port=8
  in9 : Inport  Port=9
  in10 : Inport  Port=10
  in11 : Inport  Port=11
  in12 : Inport  Port=12
  concatenate : xbsIndex_r4/Concat  num_inputs=12  dbl_ovrd=off  block_type=concat
  reinterpret{1..12} (12 alike) : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  bus_out : Outport
  wires:
  concatenate/1 -> bus_out/1
  in1/1 -> reinterpret1/1
  reinterpret1/1 -> concatenate/1
  in2/1 -> reinterpret2/1
  reinterpret2/1 -> concatenate/2
  in3/1 -> reinterpret3/1
  reinterpret3/1 -> concatenate/3
  in4/1 -> reinterpret4/1
  reinterpret4/1 -> concatenate/4
  in5/1 -> reinterpret5/1
  reinterpret5/1 -> concatenate/5
  in6/1 -> reinterpret6/1
  reinterpret6/1 -> concatenate/6
  in7/1 -> reinterpret7/1
  reinterpret7/1 -> concatenate/7
  in8/1 -> reinterpret8/1
  reinterpret8/1 -> concatenate/8
  in9/1 -> reinterpret9/1
  reinterpret9/1 -> concatenate/9
  in10/1 -> reinterpret10/1
  reinterpret10/1 -> concatenate/10
  in11/1 -> reinterpret11/1
  reinterpret11/1 -> concatenate/11
  in12/1 -> reinterpret12/1
  reinterpret12/1 -> concatenate/12

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_convert/conv1 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=binary_point_i, n_bits_out=bit_width_o, bin_pt_out=binary_point_o, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=csp_latency}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1

== system snap_tut_corr/fft_wideband_real/fft_direct/butterfly1_0/bus_convert/conv10 ==
  din : Inport
  all_0s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  all_1s : xbsIndex_r4/Logical  logical_function=NAND  inputs=3  en=off  latency=1  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  and : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=16  bin_pt=0  align_bp=on  dbl_ovrd=off  block_type=logical
  convert : Subsystem  AncestorBlock=casper_library_misc/convert  mask(convert){bin_pt_in=binary_point_i, n_bits_out=bit_width_o, bin_pt_out=binary_point_o, quantization=Round  (unbiased: Even Values), overflow=Wrap, csp_latency=csp_latency}
      mask prompts: bin_pt_in "Binary Point In"; n_bits_out "Bit Width Out"; bin_pt_out "Binary Point Out"; csp_latency "Latency"
      mask help: Convert input value to the specified bit width and precision. Does not support upscaling number of fractional bits (eg 8_5 to 8_4 is ok, but not 8_4 to 8_5).
      mask init:
      | convert_init(gcb, ...
      |     'bin_pt_in',bin_pt_in, ...
      |     'n_bits_out',n_bits_out,...
      |     'bin_pt_out',bin_pt_out, ...
      |     'quantization',quantization,...
      |     'overflow',overflow,...
      |     'csp_latency',csp_latency);
  invert1 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert2 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  invert3 : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  dout : Outport
  of : Outport  Port=2
  wires:
  din/1 -> convert/1(in), slice1/1, slice2/1, slice3/1
  convert/1(out) -> dout/1
  slice1/1 -> all_1s/1, invert1/1
  invert1/1 -> all_0s/1
  slice2/1 -> all_1s/2, invert2/1
  invert2/1 -> all_0s/2
  slice3/1 -> all_1s/3, invert3/1
  invert3/1 -> all_0s/3
  all_0s/1 -> and/1
  all_1s/1 -> and/2
  and/1 -> of/1
