simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 4 of 131)

== system snap_tut_corr/pulse_ext6 ==
  in : Inport
  Constant5 : xbsIndex_r4/Constant  const=pulse_len  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=bits  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter3 : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=1023  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Relational5 : xbsIndex_r4/Relational  mode=a!=b  op_type=Bool  en=off  latency=0  dbl_ovrd=off  block_type=relational
  edge_detect : Subsystem  AncestorBlock=casper_library_misc/edge_detect  mask(edge_detect){edge=Rising, polarity=Active High, x_in=[0 0.08 0.08 0.16 0.16 0.24 0.24 0.32 0.32 0.4], y_in=[-1 -1  1  1  1  1  1  1  1  1], x_out=[0.6 0.68 0.68 0.76 0.76 0.84 0.84 0.92 0.92 1], y_out=[-1 -1  1  1 -1 -1 -1 -1 -1 -1]}
      mask prompts: edge "Edge Type"; polarity "Output Polarity"; x_in "Input X Positions"; y_in "Input Y Positions"; x_out "Output X Positions"; y_out "Output Y Positions"
      mask help: Output is active for one-cycle after each edge of the specified type (i.e. rising, falling or both).
      mask init:
      | edge_detect_init(gcb,...
      |     'edge',edge,...
      |     'polarity',polarity,...
      |     'x_in',x_in,...
      |     'x_out',x_out,...
      |     'y_in',y_in,...
      |     'y_out',y_out);
      | 
      | x_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_in'));
      | x_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'x_out'));
      | y_in_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_in'));
      | y_out_num=str2num(getfield(getfield(get_param(gcb,'UserData'),'parameters'),'y_out'));
  out : Outport
  wires:
  edge_detect/1(out) -> Counter3/1
  in/1 -> edge_detect/1(in)
  Relational5/1 -> out/1, Counter3/2
  Constant5/1 -> Relational5/2
  Counter3/1 -> Relational5/1

== system snap_tut_corr/quant0 ==
  sync : Inport
  din : Inport  Port=2
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Boolean  arith_type=Boolean  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=10  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Delay{1..3,5} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Delay{6,18..19,25} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay4 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Logical5 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Slice11 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice14 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=16  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  coeffs : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=10, data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=[0:2^10-1], sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  round0 : Subsystem
  round1 : Subsystem
  sync_out : Outport
  clip_out : Outport  Port=2
  dout0 : Outport  Port=3
  dout1 : Outport  Port=4
  wires:
  round0/2(clip) -> Logical5/1
  round1/2(clip) -> Logical5/2
  Delay19/1 -> Delay4/1
  coeffs/1(data_out) -> Delay1/1
  Slice14/1 -> round0/2(scale)
  Slice11/1 -> round1/2(scale)
  Delay18/1 -> Delay3/1
  Delay25/1 -> Delay2/1
  sync/1 -> Counter/1, Delay6/1
  Delay4/1 -> sync_out/1
  round0/1(dout) -> dout0/1
  Logical5/1 -> Delay5/1
  bus_expand/2(lsb_out1) -> Delay25/1
  round1/1(dout) -> dout1/1
  Delay1/1 -> Slice11/1, Slice14/1
  Delay2/1 -> round1/1(din)
  Delay3/1 -> round0/1(din)
  Delay5/1 -> clip_out/1
  bus_expand/1(msb_out2) -> Delay18/1
  din/1 -> bus_expand/1(bus_in)
  Delay6/1 -> Delay19/1
  Counter/1 -> coeffs/1(addr)
  Constant/1 -> coeffs/2(data_in)
  Constant1/1 -> coeffs/3(we)

== system snap_tut_corr/quant1 ==
  sync : Inport
  din : Inport  Port=2
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Boolean  arith_type=Boolean  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=10  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Delay{1..3,5} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Delay{6,18..19,25} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay4 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Logical5 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Slice11 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice14 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=16  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  coeffs : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=10, data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=[0:2^10-1], sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  round0 : Subsystem
  round1 : Subsystem
  sync_out : Outport
  clip_out : Outport  Port=2
  dout0 : Outport  Port=3
  dout1 : Outport  Port=4
  wires:
  round0/2(clip) -> Logical5/1
  round1/2(clip) -> Logical5/2
  Delay19/1 -> Delay4/1
  coeffs/1(data_out) -> Delay1/1
  Slice14/1 -> round0/2(scale)
  Slice11/1 -> round1/2(scale)
  Delay18/1 -> Delay3/1
  Delay25/1 -> Delay2/1
  sync/1 -> Counter/1, Delay6/1
  Delay4/1 -> sync_out/1
  round0/1(dout) -> dout0/1
  Logical5/1 -> Delay5/1
  bus_expand/2(lsb_out1) -> Delay25/1
  round1/1(dout) -> dout1/1
  Delay1/1 -> Slice11/1, Slice14/1
  Delay2/1 -> round1/1(din)
  Delay3/1 -> round0/1(din)
  Delay5/1 -> clip_out/1
  bus_expand/1(msb_out2) -> Delay18/1
  din/1 -> bus_expand/1(bus_in)
  Delay6/1 -> Delay19/1
  Counter/1 -> coeffs/1(addr)
  Constant/1 -> coeffs/2(data_in)
  Constant1/1 -> coeffs/3(we)

== system snap_tut_corr/quant2 ==
  sync : Inport
  din : Inport  Port=2
  Constant : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Constant1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Boolean  arith_type=Boolean  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=10  bin_pt=0  load_pin=off  rst=on  en=off  explicit_period=on  period=1  use_behavioral_HDL=off  implementation=Fabric  dbl_ovrd=off  block_type=counter
  Delay{1..3,5} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Delay{6,18..19,25} (4 alike) : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Delay4 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=6  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Logical5 : xbsIndex_r4/Logical  logical_function=OR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  Slice11 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  Slice14 : xbsIndex_r4/Slice  nbits=16  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=16  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  bus_expand : Subsystem  AncestorBlock=casper_library_flow_control/bus_expand  mask(bus_expand){mode=divisions of equal size, outputNum=2, outputWidth=36, outputBinaryPt=0, outputArithmeticType=0, show_format=off, outputToWorkspace=off, variablePrefix=out, outputToModelAsWell=on}
      mask prompts: outputNum "Number of outputs:"; outputWidth "Output width:"; outputBinaryPt "Output binary point position:"; outputArithmeticType "Output arithmetic type (ufix=0, fix=1, bool=2):"; show_format "Print format string?"; outputToWorkspace "Output to workspace?"; variablePrefix "Variable name prefix:"; outputToModelAsWell "Output to model as well?"
      mask help: Expands a 'bus' made using a bus_create or Xilinx concat block. The input will be divided into the specified number of outputs with the specified arithmetic types. Divisions are made from most significant bit.
      mask init:
      | bus_expand_init(gcb,...
      |     'mode', mode, ...
      |     'outputNum', outputNum, ...
      |     'outputWidth', outputWidth, ...
      |     'outputBinaryPt', outputBinaryPt, ...
      |     'outputArithmeticType', outputArithmeticType, ...
      |     'show_format', show_format, ...
      |     'outputToWorkspace', outputToWorkspace, ...
      |     'variablePrefix', variablePrefix, ...
      |     'outputToModelAsWell', outputToModelAsWell);
  coeffs : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=10, data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=[0:2^10-1], sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  round0 : Subsystem
  round1 : Subsystem
  sync_out : Outport
  clip_out : Outport  Port=2
  dout0 : Outport  Port=3
  dout1 : Outport  Port=4
  wires:
  round0/2(clip) -> Logical5/1
  round1/2(clip) -> Logical5/2
  Delay19/1 -> Delay4/1
  coeffs/1(data_out) -> Delay1/1
  Slice14/1 -> round0/2(scale)
  Slice11/1 -> round1/2(scale)
  Delay18/1 -> Delay3/1
  Delay25/1 -> Delay2/1
  sync/1 -> Counter/1, Delay6/1
  Delay4/1 -> sync_out/1
  round0/1(dout) -> dout0/1
  Logical5/1 -> Delay5/1
  bus_expand/2(lsb_out1) -> Delay25/1
  round1/1(dout) -> dout1/1
  Delay1/1 -> Slice11/1, Slice14/1
  Delay2/1 -> round1/1(din)
  Delay3/1 -> round0/1(din)
  Delay5/1 -> clip_out/1
  bus_expand/1(msb_out2) -> Delay18/1
  din/1 -> bus_expand/1(bus_in)
  Delay6/1 -> Delay19/1
  Counter/1 -> coeffs/1(addr)
  Constant/1 -> coeffs/2(data_in)
  Constant1/1 -> coeffs/3(we)

== system snap_tut_corr/snap_adc ==
  a1_sim : Inport
  a2_sim : Inport  Port=2
  a3_sim : Inport  Port=3
  a4_sim : Inport  Port=4
  b1_sim : Inport  Port=5
  b2_sim : Inport  Port=6
  b3_sim : Inport  Port=7
  b4_sim : Inport  Port=8
  c1_sim : Inport  Port=9
  c2_sim : Inport  Port=10
  c3_sim : Inport  Port=11
  c4_sim : Inport  Port=12
  snap_tut_corr_snap_adc_a{1..4} (4 alike) : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=7  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_snap_adc_b{1..4} (4 alike) : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=7  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_snap_adc_c{1..4} (4 alike) : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=7  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization="Round  (unbiased: +/- Inf)"  overflow=Saturate  period=1  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  a1 : Outport
  a2 : Outport  Port=2
  a3 : Outport  Port=3
  a4 : Outport  Port=4
  b1 : Outport  Port=5
  b2 : Outport  Port=6
  b3 : Outport  Port=7
  b4 : Outport  Port=8
  c1 : Outport  Port=9
  c2 : Outport  Port=10
  c3 : Outport  Port=11
  c4 : Outport  Port=12
  wires:
  a1_sim/1 -> snap_tut_corr_snap_adc_a1/1
  snap_tut_corr_snap_adc_a1/1 -> a1/1  "a1"
  a2_sim/1 -> snap_tut_corr_snap_adc_a2/1
  snap_tut_corr_snap_adc_a2/1 -> a2/1  "a2"
  a3_sim/1 -> snap_tut_corr_snap_adc_a3/1
  snap_tut_corr_snap_adc_a3/1 -> a3/1  "a3"
  a4_sim/1 -> snap_tut_corr_snap_adc_a4/1
  snap_tut_corr_snap_adc_a4/1 -> a4/1  "a4"
  b1_sim/1 -> snap_tut_corr_snap_adc_b1/1
  snap_tut_corr_snap_adc_b1/1 -> b1/1  "b1"
  b2_sim/1 -> snap_tut_corr_snap_adc_b2/1
  snap_tut_corr_snap_adc_b2/1 -> b2/1  "b2"
  b3_sim/1 -> snap_tut_corr_snap_adc_b3/1
  snap_tut_corr_snap_adc_b3/1 -> b3/1  "b3"
  b4_sim/1 -> snap_tut_corr_snap_adc_b4/1
  snap_tut_corr_snap_adc_b4/1 -> b4/1  "b4"
  c1_sim/1 -> snap_tut_corr_snap_adc_c1/1
  snap_tut_corr_snap_adc_c1/1 -> c1/1  "c1"
  c2_sim/1 -> snap_tut_corr_snap_adc_c2/1
  snap_tut_corr_snap_adc_c2/1 -> c2/1  "c2"
  c3_sim/1 -> snap_tut_corr_snap_adc_c3/1
  snap_tut_corr_snap_adc_c3/1 -> c3/1  "c3"
  c4_sim/1 -> snap_tut_corr_snap_adc_c4/1
  snap_tut_corr_snap_adc_c4/1 -> c4/1  "c4"

== system snap_tut_corr/snapshot_eq ==
  in_quant0 : Inport
  in_quant1 : Inport  Port=2
  in_quant2 : Inport  Port=3
  we : Inport  Port=4
  trig : Inport  Port=5
  assert_quant0 : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=16  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  assert_quant1 : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=16  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  assert_quant2 : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=16  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  buscreate : Subsystem  AncestorBlock=casper_library_flow_control/bus_create  mask(bus_create){inputNum=3}
      mask prompts: inputNum "Number of inputs:"
      mask init:
      | bus_create_init(gcb,...
      |     'inputNum', inputNum);
  ss : Subsystem  Tag=casper:snapshot  AncestorBlock=casper_library_scopes/snapshot  mask(snapshot){storage=bram, dram_dimm=2, dram_clock=250, nsamples=10, data_width=64, offset=off, circap=off, value=off, ext_arm=off, ext_circ=off, provide_outputs=off, use_dsp48=on}
      mask prompts: storage "Storage medium"; dram_dimm "DRAM dimm"; dram_clock "DRAM clock rate"; nsamples "Number of Samples (2^?)"; data_width "Data width"; offset "Start delay support"; circap "Circular capture support"; value "Extra value capture support"; ext_arm "External arm support"; ext_circ "External circular capture support"; provide_outputs "Provide outputs"; use_dsp48 "Use DSP48s to implement counters"
      mask help: Standard snap block, but with the following optional extras; 1) Optionally delay the fabric trigger by a user-specified number of valids. 2) Capture continuously after a trigger until a stop pulse is received. Data is captured into BRAM continuously, with old data being overwritten until a stop command is received. Then stop capturing when memory is filled. This enables you to get some data before and some data after the stop pulse. Use the 'tr_en_cnt' register to determine where you are in your vector. 'Addr' register's MSb now indicates 'busy capturing'. 3) Optionally capture a value on an i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
      mask init:
      | snapshot_init(gcb, ...
      |     'storage', storage, ...
      |     'dram_dimm', dram_dimm, ...
      |     'dram_clock', dram_clock, ...
      |     'nsamples', nsamples, ...
      |     'data_width', data_width, ...
      |     'offset', offset, ...
      |     'circap', circap, ...
      |     'value', value, ...
      |     'ext_arm', ext_arm, ...
      |     'ext_circ', ext_circ, ...
      |     'provide_outputs', 'off', ...
      |     'use_dsp48', use_dsp48);
  arm_out : Outport
  wires:
  ss/1(arm_out) -> arm_out/1
  buscreate/1(bus_out) -> ss/1(din)
  in_quant0/1 -> assert_quant0/1
  assert_quant0/1 -> buscreate/1(in1)
  in_quant1/1 -> assert_quant1/1
  assert_quant1/1 -> buscreate/2(in2)
  in_quant2/1 -> assert_quant2/1
  assert_quant2/1 -> buscreate/3(in3)
  we/1 -> ss/2(we)
  trig/1 -> ss/3(trig)

== system snap_tut_corr/status ==
  out_reg : Inport
  assert_reg : xbsIndex_r4/Assert  assert_type=on  type_source=Explicitly  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  assert_rate=off  rate_source=Explicitly  period=1  output_port=on  block_type=assert
  cast_gw : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=1  pipeline=off  dbl_ovrd=off  block_type=convert
  io_delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=0  reg_retiming=on  dbl_ovrd=off  block_type=delay
  reint1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  snap_tut_corr_status_user_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  sim_out : Outport
  wires:
  io_delay/1 -> cast_gw/1
  cast_gw/1 -> snap_tut_corr_status_user_data_in/1
  snap_tut_corr_status_user_data_in/1 -> sim_out/1
  out_reg/1 -> assert_reg/1
  assert_reg/1 -> reint1/1
  reint1/1 -> io_delay/1

== system snap_tut_corr/sync_gen ==
  arm : Inport
  pps : Inport  Port=2
  Constant : xbsIndex_r4/Constant  const=sync_period  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=sync_period_bits+1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  Delay1 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  Delay2 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=on  dbl_ovrd=off  block_type=delay
  rst_gen : Subsystem  mask{reset_period=1}
      mask prompts: reset_period "Min period of reset (pps pulses)"
      mask init:
      | %reset_period = eval(get_param(gcb,'reset_period'))
      | %bits = ceil(log2(reset_period))
      | %set_param([gcb,'/Counter'],'n_bits',num2str(bits));
      | %set_param([gcb,'/Counter'],'start_count', num2str(reset_period))
      | %set_param([gcb,'/Constant'],'n_bits',num2str(bits));
  sync_gen : Subsystem  mask{sync_gen_bits=sync_period_bits+1}
      mask prompts: sync_gen_bits "Size of sync generator counter"
  mrst : Outport
  sync : Outport  Port=2
  wires:
  arm/1 -> rst_gen/1(arm)
  pps/1 -> rst_gen/2(sync_in)
  sync_gen/1(sync) -> Delay2/1
  rst_gen/1(mrst) -> sync_gen/1(rst), Delay1/1
  Delay1/1 -> mrst/1
  Delay2/1 -> sync/1
  Constant/1 -> sync_gen/2(sync_period)

== system snap_tut_corr/acc_ctrl/edge_detect ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/acc_ctrl/edge_detect1 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/acc_ctrl/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=NOR  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/bus_or/bus_expand4 ==
  bus_in : Inport
  slice1 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-2  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice2 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=-1  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice3 : xbsIndex_r4/Slice  nbits=1  boolean_output=on  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  msb_out3 : Outport
  out2 : Outport  Port=2
  lsb_out1 : Outport  Port=3
  wires:
  bus_in/1 -> slice3/1, slice2/1, slice1/1
  slice3/1 -> msb_out3/1
  slice2/1 -> out2/1
  slice1/1 -> lsb_out1/1

== system snap_tut_corr/calc_adc_sum_sq/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/calc_adc_sum_sq4/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/calc_adc_sum_sq5/edge_detect2 ==
  in : Inport
  Delay : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=1  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Inverter : xbsIndex_r4/Inverter  en=off  latency=0  dbl_ovrd=off  block_type=inv
  edge_op : xbsIndex_r4/Logical  logical_function=AND  inputs=2  en=off  latency=0  precision=Full  arith_type=Unsigned  n_bits=8  bin_pt=2  align_bp=on  dbl_ovrd=off  block_type=logical
  out : Outport
  wires:
  Inverter/1 -> edge_op/1
  edge_op/1 -> out/1
  in/1 -> Inverter/1, Delay/1
  Delay/1 -> edge_op/2

== system snap_tut_corr/dir_x0/aa ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=chan_bits  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Gateway Out{,1..3} (4 alike) : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  block_type=gatewayout
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Scope : Scope  NumInputPorts=4
  Terminator : Terminator
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_32bit : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Reinterpret/1 -> real/2(data_in), Gateway Out1/1
  Counter/1 -> real/1(addr), Gateway Out/1
  vacc_32bit/2(valid) -> Counter/2, real/3(we), Gateway Out2/1
  Delay3/1 -> Counter/1, vacc_32bit/2(new_acc), Gateway Out3/1
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  vacc_32bit/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  cmult_dsp48e/1(c_re) -> vacc_32bit/1(din)
  real/1(data_out) -> Terminator/1
  Gateway Out/1 -> Scope/1
  Gateway Out1/1 -> Scope/2
  Gateway Out2/1 -> Scope/3
  Gateway Out3/1 -> Scope/4

== system snap_tut_corr/dir_x0/ab ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  Counter/1 -> real/1(addr), imag/1(addr)
  vacc_1/1(dout) -> Reinterpret1/1
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_0/2(valid) -> real/3(we), Counter/2
  vacc_0/1(dout) -> Reinterpret/1
  new_acc/1 -> Delay3/1
  Delay3/1 -> vacc_0/2(new_acc), Counter/1, vacc_1/2(new_acc)
  c+di/1 -> c_to_ri1/1(c)
  a+bi/1 -> c_to_ri/1(c)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)

== system snap_tut_corr/dir_x0/ac ==
  a+bi : Inport
  c+di : Inport  Port=2
  new_acc : Inport  Port=3
  Counter : xbsIndex_r4/Counter  cnt_type=Free Running  cnt_to=Inf  operation=Up  start_count=0  cnt_by_val=1  arith_type=Unsigned  n_bits=11  bin_pt=0  load_pin=off  rst=on  en=on  explicit_period=off  period=1  use_behavioral_HDL=off  implementation=Fabric  use_rpm=on  dbl_ovrd=off  block_type=counter
  Delay3 : xbsIndex_r4/Delay  rst=off  infoeditControl=Selection of Reset will increase slice count due to use of real FFs and instead of SRLs  en=off  latency=4  reg_retiming=off  dbl_ovrd=off  block_type=delay
  Reinterpret : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  Reinterpret1 : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type=Unsigned  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  c_to_ri : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  c_to_ri1 : Subsystem  mask(Complex to Real-Imag){n_bits=4, bin_pt=3}
      mask prompts: n_bits "Bit Width"; bin_pt "Binary Point"
      mask help: Outputs real and imaginary components of a complex input.
      mask init:
      | annotation=sprintf('%d_%d r/i',n_bits,bin_pt);
      | set_param(gcb,'AttributesFormatString',annotation);
  cmult_dsp48e : Subsystem  AncestorBlock=casper_library_multipliers/cmult_dsp48e  mask(cmult_dsp48e){n_bits_a=4, bin_pt_a=3, n_bits_b=4, bin_pt_b=3, conjugated=on, full_precision=on, n_bits_c=37, bin_pt_c=34, quantization=Truncate, overflow=Wrap, cast_latency=0}
      mask prompts: n_bits_a "Bit width 'a'"; bin_pt_a "Binary point 'a'"; n_bits_b "Bit width 'b'"; bin_pt_b "Binary point 'b'"; conjugated "Conjugate"; full_precision "Full precision"; n_bits_c "Bit width out"; bin_pt_c "Binary point out"; cast_latency "Cast Latency"
      mask help: Multiplies two complex numbers using 4 DSP48Es. Conjugation is optional. Re{a} and Im{a} can be up to 25 bits. Re{b} and Im{b} can be up to 18 bits.
      mask init:
      | cmult_dsp48e_init(gcb, ...
      |     'n_bits_a', n_bits_a, ...
      |     'bin_pt_a', bin_pt_a, ...
      |     'n_bits_b', n_bits_b, ...
      |     'bin_pt_b', bin_pt_b, ...
      |     'conjugated', conjugated, ...
      |     'full_precision', full_precision, ...
      |     'n_bits_c', n_bits_c, ...
      |     'bin_pt_c', bin_pt_c, ...
      |     'quantization', quantization, ...
      |     'overflow', overflow, ...
      |     'cast_latency', cast_latency);
  imag : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  real : Subsystem  Tag=xps:bram  AncestorBlock=xps_library/Memory/shared_bram  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, reg_prim_output=off, reg_core_output=off, optimization=Minimum_Area, data_bin_pt=0, init_vals=0, sample_rate=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data Width"; reg_prim_output "Register Primitive Output"; reg_core_output "Register Core Output"; data_bin_pt "Data Binary Point"; init_vals "Initial values (simulation only)"; sample_rate "Sample rate"
      mask init:
      | shared_bram_mask;
  vacc_0 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  vacc_1 : Subsystem  mask{n_chans=n_chans}
      mask prompts: n_chans "Number of channels"
      mask init:
      | chan_bits=ceil(log2(n_chans));
  wires:
  cmult_dsp48e/1(c_re) -> vacc_0/1(din)
  cmult_dsp48e/2(c_im) -> vacc_1/1(din)
  c_to_ri/1(re) -> cmult_dsp48e/1(a_re)
  c_to_ri/2(im) -> cmult_dsp48e/2(a_im)
  c_to_ri1/1(re) -> cmult_dsp48e/3(b_re)
  c_to_ri1/2(im) -> cmult_dsp48e/4(b_im)
  a+bi/1 -> c_to_ri/1(c)
  c+di/1 -> c_to_ri1/1(c)
  Delay3/1 -> vacc_1/2(new_acc), Counter/1, vacc_0/2(new_acc)
  new_acc/1 -> Delay3/1
  vacc_0/1(dout) -> Reinterpret/1
  vacc_0/2(valid) -> Counter/2, real/3(we)
  Reinterpret/1 -> real/2(data_in)
  vacc_1/2(valid) -> imag/3(we)
  Reinterpret1/1 -> imag/2(data_in)
  vacc_1/1(dout) -> Reinterpret1/1
  Counter/1 -> imag/1(addr), real/1(addr)
