simulink model "snap_tut_corr"  (R2018a)
settings: Solver=VariableStepDiscrete  StartTime=0.0  StopTime=100  RelTol=1e-3
undefined symbols (not defined in the file): Area, behavioral, Behavioral, Bit, Both, BRAM, bram, c, core, d, Falling, getfield, hamming, hex2dec, led, Location, logic, Lower, Minimum_Area, out, quant0, quant1, quant2, reg, repmat, Rising, ROACH, ROACH2, SNAP, Speed, sync_in, Truncate, Unsigned, Upper, Width, Wrap, xc7k160t
libraries: xbsIndex_r4 x17901, casper_library_misc x29, xbsReplacements_r4 x20, casper_library_delays x14, xps_library x5
(part 12 of 131)

== system snap_tut_corr/dir_x0/bb/real ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, data_bin_pt=0, init_vals=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_dir_x0_bb_real_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bb_real_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bb_real_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_dir_x0_bb_real_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_dir_x0_bb_real_data_out/1
  snap_tut_corr_dir_x0_bb_real_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_dir_x0_bb_real_addr/1
  convert_din1/1 -> snap_tut_corr_dir_x0_bb_real_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_dir_x0_bb_real_we/1 -> Terminator2/1
  snap_tut_corr_dir_x0_bb_real_data_in/1 -> Terminator1/1
  snap_tut_corr_dir_x0_bb_real_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_dir_x0_bb_real_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/dir_x0/bb/vacc_32bit ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  dbl_ovrd=off  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem  mask(delay_bram){DelayLen=n_chans - 2, bram_latency=2}
      mask prompts: DelayLen "Delay By:"; bram_latency "BRAM Latency"
      mask help: A delay block that uses BRAM for its storage.
      mask init:
      | if (DelayLen <= bram_latency)
      | 	error('delay value must be greater than BRAM Latency');
      | end
      | BitWidth = max(ceil(log2(DelayLen)), 2);
  pulse_ext : Subsystem  mask(pulse_ext){pulse_len=n_chans}
      mask prompts: pulse_len "Length of Pulse"
      mask help: Extends a boolean signal to be high for the specified number of clocks after the last high input.
      mask init:
      | bits = ceil(log2(pulse_len+1));
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  zero/1 -> Mux0/3
  Mux0/1 -> Adder0/2
  pulse_ext/1(out) -> Mux0/1, valid/1
  din/1 -> Adder0/1
  new_acc/1 -> pulse_ext/1(in)
  delay_bram/1(Out1) -> Mux0/2, dout/1
  Adder0/1 -> delay_bram/1(In1)

== system snap_tut_corr/dir_x0/bc/c_to_ri ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  c/1 -> slice_im/1, slice_re/1
  force_im/1 -> im/1
  force_re/1 -> re/1
  slice_im/1 -> force_im/1
  slice_re/1 -> force_re/1

== system snap_tut_corr/dir_x0/bc/c_to_ri1 ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  c/1 -> slice_im/1, slice_re/1
  force_im/1 -> im/1
  force_re/1 -> re/1
  slice_im/1 -> force_im/1
  slice_re/1 -> force_re/1

== system snap_tut_corr/dir_x0/bc/cmult_dsp48e ==
  a_re : Inport
  a_im : Inport  Port=2
  b_re : Inport  Port=3
  b_im : Inport  Port=4
  Convert{,1..2,5} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=30  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  Convert{3..4,6..7} (4 alike) : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=18  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  DSP48E_0 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_1 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_2 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=off  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=on  use_multsignout=off  use_carrycascout=off  pipeline_a=1  pipeline_b=1  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  DSP48E_3 : xbsIndex_r4/DSP48E  use_a=Direct from A Port  use_b=Direct from B Port  reset_preg=off  pattern_from_creg=off  pattern='000000000000'  mask_from_creg=off  pattern_mask='3FFFFFFFFFFF'  sel_rounding_mask=Select mask  use_op=off  use_creg=off  rst_all=off  en_all=off  use_pcin=on  use_carrycascin=off  use_multsignin=off  use_carryout=off  use_patterndetect=off  use_patternbdetect=off  use_overflow=off  use_underflow=off  use_acout=off  use_bcout=off  use_pcout=off  use_multsignout=off  use_carrycascout=off  pipeline_a=2  pipeline_b=2  pipeline_acout=1  pipeline_bcout=1  pipeline_c=on  pipeline_p=on  pipeline_mult=on  pipeline_opmode=on  pipeline_alumode=on  pipeline_carryin=on  pipeline_carryinsel=on  rst_a=off  rst_b=off  rst_c=off  rst_mult=off  rst_p=off  rst_carry_in=off  rst_alumode=off  rst_ctrl=off  en_a1=off  en_a2=off  en_b1=off  en_b2=off  en_c=off  en_mult=off  en_p=off  en_carry_in=off  en_alumode=off  en_multcarryin=off  en_ctrl=off  use_synth_model=off  addsub_mode=ONE48  xl_useadderonly=off  block_type=dsp48e
  Terminator : Terminator
  Terminator1 : Terminator
  alumode0 : xbsIndex_r4/Constant  const=3  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode1 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode2 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  alumode3 : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=4  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryin{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  carryinsel{0..3} (4 alike) : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=3  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  cast_c_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  cast_c_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=9  bin_pt=6  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  opmode0 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode1 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode2 : xbsIndex_r4/Constant  const=5  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  opmode3 : xbsIndex_r4/Constant  const=21  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=7  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  explicit_period=off  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  realign_a_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  realign_a_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  realign_b_im : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  realign_b_re : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type="Signed  (2's comp)"  n_bits=4  bin_pt=3  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=on  dbl_ovrd=off  block_type=convert
  reinterp_a_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_a_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_b_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=0  block_type=reinterpret
  reinterp_c_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  reinterp_c_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=6  block_type=reinterpret
  c_re : Outport
  c_im : Outport  Port=2
  wires:
  reinterp_c_im/1 -> cast_c_im/1
  DSP48E_1/1 -> reinterp_c_im/1
  carryinsel0/1 -> DSP48E_0/6
  carryin0/1 -> DSP48E_0/5
  alumode0/1 -> DSP48E_0/4
  opmode0/1 -> DSP48E_0/3
  Convert7/1 -> DSP48E_0/2
  Convert5/1 -> DSP48E_0/1
  Convert6/1 -> DSP48E_1/2
  carryinsel1/1 -> DSP48E_1/7
  carryin1/1 -> DSP48E_1/6
  alumode1/1 -> DSP48E_1/5
  opmode1/1 -> DSP48E_1/4
  DSP48E_0/2 -> DSP48E_1/3
  DSP48E_0/1 -> Terminator1/1
  Convert1/1 -> DSP48E_1/1
  DSP48E_3/1 -> reinterp_c_re/1
  reinterp_c_re/1 -> cast_c_re/1
  carryinsel2/1 -> DSP48E_2/6
  carryin2/1 -> DSP48E_2/5
  alumode2/1 -> DSP48E_2/4
  opmode2/1 -> DSP48E_2/3
  Convert4/1 -> DSP48E_2/2
  Convert2/1 -> DSP48E_2/1
  Convert3/1 -> DSP48E_3/2
  carryinsel3/1 -> DSP48E_3/7
  carryin3/1 -> DSP48E_3/6
  alumode3/1 -> DSP48E_3/5
  opmode3/1 -> DSP48E_3/4
  DSP48E_2/2 -> DSP48E_3/3
  DSP48E_2/1 -> Terminator/1
  Convert/1 -> DSP48E_3/1
  realign_a_re/1 -> reinterp_a_re/1
  realign_a_im/1 -> reinterp_a_im/1
  realign_b_re/1 -> reinterp_b_re/1
  realign_b_im/1 -> reinterp_b_im/1
  reinterp_a_re/1 -> Convert2/1, Convert5/1
  reinterp_a_im/1 -> Convert1/1, Convert/1
  reinterp_b_re/1 -> Convert4/1, Convert6/1
  reinterp_b_im/1 -> Convert7/1, Convert3/1
  cast_c_re/1 -> c_re/1
  cast_c_im/1 -> c_im/1
  a_re/1 -> realign_a_re/1
  a_im/1 -> realign_a_im/1
  b_re/1 -> realign_b_re/1
  b_im/1 -> realign_b_im/1

== system snap_tut_corr/dir_x0/bc/imag ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, data_bin_pt=0, init_vals=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_dir_x0_bc_imag_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bc_imag_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bc_imag_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_dir_x0_bc_imag_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_dir_x0_bc_imag_data_out/1
  snap_tut_corr_dir_x0_bc_imag_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_dir_x0_bc_imag_addr/1
  convert_din1/1 -> snap_tut_corr_dir_x0_bc_imag_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_dir_x0_bc_imag_we/1 -> Terminator2/1
  snap_tut_corr_dir_x0_bc_imag_data_in/1 -> Terminator1/1
  snap_tut_corr_dir_x0_bc_imag_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_dir_x0_bc_imag_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/dir_x0/bc/real ==
  addr : Inport
  data_in : Inport  Port=2
  we : Inport  Port=3
  Terminator : Terminator
  Terminator1 : Terminator
  Terminator2 : Terminator
  calc_add : Subsystem  mask{data_width=32, addr_width=10, sample_rate=sample_rate}
      mask prompts: data_width "data width"; addr_width "address width"; sample_rate "sample rate"
  convert_addr : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=addr_width  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_din1 : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  convert_we : xbsIndex_r4/Convert  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=1  bin_pt=0  float_type=Single  exp_bits=8  fraction_bits=24  quantization=Truncate  overflow=Wrap  en=off  latency=0  pipeline=off  dbl_ovrd=off  block_type=convert
  munge_in : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  munge_out : Subsystem  AncestorBlock=casper_library_flow_control/munge  mask(munge){divisions=1, div_size=32, order=[0], arith_type_out=Unsigned, bin_pt_out=0}
      mask prompts: divisions "Number of divisions"; div_size "Division size (bits)"; order "Division packing order"; arith_type_out "Output arithmetic type"; bin_pt_out "Output binary point"
      mask help: Splits an input bus into the specified number of divisions and then recombines them in the order specified (most significant division = 0,least = number divisions-1)
      mask init:
      | munge_init(gcb, ...
      |     'divisions', divisions, ...
      |     'div_size', div_size, ...
      |     'order', order, ...
      |     'arith_type_out', arith_type_out, ...
      |     'bin_pt_out', bin_pt_out);
  sim_mem : Subsystem  mask{arith_type=Unsigned, addr_width=max(chan_bits,10), data_width=32, data_bin_pt=0, init_vals=[0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  0  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, sample_rate=1, csp_latency=1}
      mask prompts: arith_type "Output Data Type"; addr_width "Address width"; data_width "Data width"; data_bin_pt "Data Binary Point"; init_vals "Initial values"; sample_rate "Sample rate"; csp_latency "Latency"
      mask init:
      | % set_param([gcb, '/data_to_xilinx'], 'arith_type', arith_type)
      | % set_param([gcb, '/data_to_xilinx'], 'n_bits', get_param(gcb, 'data_width'))
  snap_tut_corr_dir_x0_bc_real_addr : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A5','B9','A9','C1','A3','G6','E9','A6','A7','A8','B8','B1','B3','D9','B5','B4','B6','C2'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bc_real_data_in : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'B21','B22','A22','B23','B19','C19','A20','A21','A23','B24','A24','A25','E18','D18','C18','B18'}  io_standard={}  block_type=gatewayout
  snap_tut_corr_dir_x0_bc_real_data_out : xbsIndex_r4/Gateway In  gui_display_data_type=Fixed-point  arith_type=Unsigned  n_bits=32  bin_pt=0  preci_type=Single  exp_width=8  frac_width=24  rows=1  columns=1  quantization=Truncate  overflow=Wrap  period=sample_rate  UseAsADC=off  ADCChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  default_value=0  timing_constraint=None  locs_specified=off  LOCs={}  io_standard={}  inherit_from_input=off  hdl_port=on  dbl_ovrd=off  block_type=gatewayin
  snap_tut_corr_dir_x0_bc_real_we : xbsIndex_r4/Gateway Out  inherit_from_input=off  hdl_port=on  rows=1  columns=1  UseAsDAC=off  DACChannel='1'  interface=None  automatic_assignment=on  address_offset=hex2dec('00')  intf_name=''  intf_description=''  timing_constraint=None  locs_specified=off  LOCs={'A14'}  io_standard={}  block_type=gatewayout
  data_out : Outport
  wires:
  munge_out/1(dout) -> data_out/1
  sim_mem/1(data_out) -> snap_tut_corr_dir_x0_bc_real_data_out/1
  snap_tut_corr_dir_x0_bc_real_data_out/1 -> munge_out/1(din)
  convert_addr/1 -> snap_tut_corr_dir_x0_bc_real_addr/1
  convert_din1/1 -> snap_tut_corr_dir_x0_bc_real_data_in/1
  data_in/1 -> munge_in/1(din)
  calc_add/1(out) -> sim_mem/1(addr), convert_addr/1
  snap_tut_corr_dir_x0_bc_real_we/1 -> Terminator2/1
  snap_tut_corr_dir_x0_bc_real_data_in/1 -> Terminator1/1
  snap_tut_corr_dir_x0_bc_real_addr/1 -> Terminator/1
  convert_we/1 -> snap_tut_corr_dir_x0_bc_real_we/1
  addr/1 -> calc_add/1(in)
  we/1 -> sim_mem/3(we), convert_we/1
  munge_in/1(dout) -> sim_mem/2(data), convert_din1/1

== system snap_tut_corr/dir_x0/bc/vacc_0 ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  dbl_ovrd=off  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem  mask(delay_bram){DelayLen=n_chans - 2, bram_latency=2}
      mask prompts: DelayLen "Delay By:"; bram_latency "BRAM Latency"
      mask help: A delay block that uses BRAM for its storage.
      mask init:
      | if (DelayLen <= bram_latency)
      | 	error('delay value must be greater than BRAM Latency');
      | end
      | BitWidth = max(ceil(log2(DelayLen)), 2);
  pulse_ext : Subsystem  mask(pulse_ext){pulse_len=n_chans}
      mask prompts: pulse_len "Length of Pulse"
      mask help: Extends a boolean signal to be high for the specified number of clocks after the last high input.
      mask init:
      | bits = ceil(log2(pulse_len+1));
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  zero/1 -> Mux0/3
  Mux0/1 -> Adder0/2
  pulse_ext/1(out) -> Mux0/1, valid/1
  din/1 -> Adder0/1
  new_acc/1 -> pulse_ext/1(in)
  Adder0/1 -> delay_bram/1(In1)
  delay_bram/1(Out1) -> dout/1, Mux0/2

== system snap_tut_corr/dir_x0/bc/vacc_1 ==
  din : Inport
  new_acc : Inport  Port=2
  Adder0 : xbsIndex_r4/AddSub  mode=Addition  use_carryin=off  use_carryout=off  en=off  latency=2  precision=User Defined  arith_type="Signed  (2's comp)"  n_bits=32  bin_pt=6  quantization=Truncate  overflow=Wrap  use_behavioral_HDL=on  hw_selection=Fabric  pipelined=off  use_rpm=on  dbl_ovrd=off  block_type=addsub
  Mux0 : xbsIndex_r4/Mux  inputs=2  en=off  latency=0  precision=Full  arith_type="Signed  (2's comp)"  n_bits=8  bin_pt=2  quantization=Truncate  overflow=Wrap  dbl_ovrd=off  block_type=mux
  delay_bram : Subsystem  mask(delay_bram){DelayLen=n_chans - 2, bram_latency=2}
      mask prompts: DelayLen "Delay By:"; bram_latency "BRAM Latency"
      mask help: A delay block that uses BRAM for its storage.
      mask init:
      | if (DelayLen <= bram_latency)
      | 	error('delay value must be greater than BRAM Latency');
      | end
      | BitWidth = max(ceil(log2(DelayLen)), 2);
  pulse_ext : Subsystem  mask(pulse_ext){pulse_len=n_chans}
      mask prompts: pulse_len "Length of Pulse"
      mask help: Extends a boolean signal to be high for the specified number of clocks after the last high input.
      mask init:
      | bits = ceil(log2(pulse_len+1));
  warn period Adder00 : xbsReplacements_r4/Warning  period=1
  zero : xbsIndex_r4/Constant  const=0  gui_display_data_type=Fixed-point  arith_type=Signed (2's comp)  n_bits=32  bin_pt=6  preci_type=Single  exp_width=8  frac_width=24  explicit_period=on  period=1  equ=P=C  opselect=C  inp2=PCIN>>17  opr=+  inp1=P  carry=CIN  dbl_ovrd=off  block_type=constant
  dout : Outport
  valid : Outport  Port=2
  wires:
  delay_bram/1(Out1) -> Mux0/2, dout/1
  Adder0/1 -> delay_bram/1(In1)
  new_acc/1 -> pulse_ext/1(in)
  din/1 -> Adder0/1
  pulse_ext/1(out) -> valid/1, Mux0/1
  Mux0/1 -> Adder0/2
  zero/1 -> Mux0/3

== system snap_tut_corr/dir_x0/cc/c_to_ri ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1

== system snap_tut_corr/dir_x0/cc/c_to_ri1 ==
  c : Inport
  force_im : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  force_re : xbsIndex_r4/Reinterpret  force_arith_type=on  arith_type="Signed  (2's comp)"  force_bin_pt=on  bin_pt=bin_pt  block_type=reinterpret
  slice_im : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Lower Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  slice_re : xbsIndex_r4/Slice  nbits=n_bits  boolean_output=off  mode=Upper Bit Location + Width  bit1=0  base1=MSB of Input  bit0=0  base0=LSB of Input  dbl_ovrd=off  block_type=slice
  re : Outport
  im : Outport  Port=2
  wires:
  slice_re/1 -> force_re/1
  slice_im/1 -> force_im/1
  force_re/1 -> re/1
  force_im/1 -> im/1
  c/1 -> slice_re/1, slice_im/1
